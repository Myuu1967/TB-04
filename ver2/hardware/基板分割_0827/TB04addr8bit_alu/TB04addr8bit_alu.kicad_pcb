# Repository Myuu1967/TB-04 (continued)

## KiCad design ver2/hardware/基板分割_0827/TB04addr8bit_ctrl/TB04addr8bit_ctrl.kicad_pcb (continued)

Parts:
C1301: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U1301: 74HC08; DIP-14_W7.62mm_Socket

Connections:
A3: U1301.13; also elsewhere on the board
A4: U1301.5; also elsewhere on the board
A5: U1301.4; also elsewhere on the board
A6: U1301.2; also elsewhere on the board
A7: U1301.1; also elsewhere on the board
GND: C1301.2, U1301.7 (GND); also elsewhere on the board
unnamed: U1301.6, U1301.10
P2: U1301.3, U1301.9; also elsewhere on the board
P4: U1301.8, U1301.12
P5: U1301.11; also elsewhere on the board
VDD: C1301.1, U1301.14 (VCC); also elsewhere on the board

Parts:
C1501, C1503, C1504, C1505, C1506, C1507: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U1501: 74AHC04; DIP-14_W7.62mm_Socket
U1503: 74HC08; DIP-14_W7.62mm_Socket
U1504, U1505: 74HC00; DIP-14_W7.62mm_Socket
U1506: 74HC32; DIP-14_W7.62mm_Socket
U1509: 74HC10; DIP-14_W7.62mm_Socket

Connections:
CD: U1504.3; also elsewhere on the board
CD_pre: U1503.8, U1504.2
CLK_C: U1503.3; also elsewhere on the board
CLK_CPU: U1506.13, U1509.9; also elsewhere on the board
CLK_Z: U1503.6; also elsewhere on the board
CS_RAM: U1501.12, U1509.11
CU: U1506.11; also elsewhere on the board
CU_pre: U1503.11, U1504.4
CU_raw: U1504.6, U1506.12
C_WE: U1503.2; also elsewhere on the board
DCR: U1504.5; also elsewhere on the board
EXE: U1504.1, U1504.10, U1505.10, U1505.13, U1509.13; also elsewhere on the board
FCH1: U1503.1, U1503.4, U1506.9; also elsewhere on the board
FCH2: U1506.10; also elsewhere on the board
GND: C1501.2, C1503.2, C1504.2, C1505.1, C1506.1, C1507.1, U1501.7 (GND), U1503.7 (GND), U1504.7 (GND), U1505.7 (GND), U1506.7 (GND), U1509.7 (GND); also elsewhere on the board
unnamed: U1506.3, U1506.4
OPR6: U1501.3; also elsewhere on the board
P2: U1501.1, U1509.1; also elsewhere on the board
P5: U1501.5; also elsewhere on the board
PC_CNT_EN: U1506.8; also elsewhere on the board
PC_LOAD: U1504.9; also elsewhere on the board
ROM_SEL: U1501.2, U1504.12
SEL_M1: U1505.12; also elsewhere on the board
SEL_Y: U1505.5; also elsewhere on the board
SP0: U1506.1, U1509.3; also elsewhere on the board
SP1: U1506.2, U1509.4; also elsewhere on the board
SP2: U1506.5, U1509.5; also elsewhere on the board
SP_CD: U1503.9; also elsewhere on the board
SP_CU: U1503.12; also elsewhere on the board
SP_NE0: U1503.10, U1506.6
SP_NE7: U1503.13, U1509.6
VDD: C1501.1, C1503.1, C1504.1, C1505.2, C1506.2, C1507.2, U1501.14 (VCC), U1503.14 (VCC), U1504.14 (VCC), U1505.14 (VCC), U1506.14 (VCC), U1509.14 (VCC); also elsewhere on the board
WR: U1505.9, U1509.10; also elsewhere on the board
WR_EXE: U1501.8, U1505.1, U1505.4
Z_WE: U1503.5; also elsewhere on the board
sel_a2: U1501.11; also elsewhere on the board
~CS_RAM: U1501.13, U1509.12; also elsewhere on the board
~Ena_RS01: U1501.10; also elsewhere on the board
~Enb_RS01: U1501.4; also elsewhere on the board
~OE_ROM: U1504.11; also elsewhere on the board
~OE_ioAddr: U1505.11; also elsewhere on the board
~P5: U1501.6, U1509.2
~PC_PE: U1504.8; also elsewhere on the board
~SEL_Y: U1505.2; also elsewhere on the board
~WE_RAM: U1509.8; also elsewhere on the board
~WR_EXE: U1501.9, U1504.13, U1505.8
~YEN_PC: U1505.6; also elsewhere on the board
~YEN_Y: U1505.3; also elsewhere on the board

Notes on the sheet:
ROM_SEL=~{A7&A6}
A7=A6=0 ~{WE}=1のとき~{OE}=0
SP=7のときそれ以上 カウントアップさせない
SP=0のときそれ以下に カウントダウンさせない

Parts:
C401, C402, C403, C404: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC401, IC402: 74HC161N; DIP-16_W7.62mm_Socket; Manufacturer_Part_Number 74HC161N
U401, U404: 74HC157; DIP-16_W7.62mm_Socket

Connections:
CLK_CPU: IC401.2 (CP), IC402.2 (CP); also elsewhere on the board
GND: C401.1, C402.1, C403.1, C404.1, IC401.8 (GND), IC402.8 (GND), U401.8 (GND), U401.15 (E), U404.8 (GND), U404.15 (E); also elsewhere on the board
MD0: U401.10 (I1c); also elsewhere on the board
MD1: U401.6 (I1b); also elsewhere on the board
MD2: U401.13 (I1d); also elsewhere on the board
MD3: U401.3 (I1a); also elsewhere on the board
MD4: U404.3 (I1a); also elsewhere on the board
MD5: U404.13 (I1d); also elsewhere on the board
MD6: U404.6 (I1b); also elsewhere on the board
MD7: U404.10 (I1c); also elsewhere on the board
unnamed: IC401.10 (CET), IC402.15 (TC)
OPR4: U401.11 (I0c); also elsewhere on the board
OPR5: U401.5 (I0b); also elsewhere on the board
OPR6: U401.14 (I0d); also elsewhere on the board
OPR7: U401.2 (I0a); also elsewhere on the board
OPR8: U404.2 (I0a); also elsewhere on the board
OPR9: U404.14 (I0d); also elsewhere on the board
OPR10: U404.5 (I0b); also elsewhere on the board
OPR11: U404.11 (I0c); also elsewhere on the board
PC0: IC402.3 (D0), U401.9 (Zc)
PC1: IC402.4 (D1), U401.7 (Zb)
PC2: IC402.5 (D2), U401.12 (Zd)
PC3: IC402.6 (D3), U401.4 (Za)
PC4: IC401.3 (D0), U404.4 (Za)
PC5: IC401.4 (D1), U404.12 (Zd)
PC6: IC401.5 (D2), U404.7 (Zb)
PC7: IC401.6 (D3), U404.9 (Zc)
PC_CNT_EN: IC401.7 (CEP), IC402.7 (CEP), IC402.10 (CET); also elsewhere on the board
PC_Q0: IC402.14 (Q0); also elsewhere on the board
PC_Q1: IC402.13 (Q1); also elsewhere on the board
PC_Q2: IC402.12 (Q2); also elsewhere on the board
PC_Q3: IC402.11 (Q3); also elsewhere on the board
PC_Q4: IC401.14 (Q0); also elsewhere on the board
PC_Q5: IC401.13 (Q1); also elsewhere on the board
PC_Q6: IC401.12 (Q2); also elsewhere on the board
PC_Q7: IC401.11 (Q3); also elsewhere on the board
SEL_PC: U401.1 (S), U404.1 (S); also elsewhere on the board
VDD: C401.2, C402.2, C403.2, C404.2, IC401.16 (VCC), IC402.16 (VCC), U401.16 (VCC), U404.16 (VCC); also elsewhere on the board
~PC_PE: IC401.9 (~PE), IC402.9 (~PE); also elsewhere on the board
~RST: IC401.1 (~MR), IC402.1 (~MR); also elsewhere on the board

Notes on the sheet:
PC_L
mAddrH
PC_H

Parts:
J801, J802, J803, J804: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical

Connections:
GND: J801.9, J801.10, J802.9, J802.10, J803.9, J803.10, J804.9, J804.10; also elsewhere on the board
OPC0: J801.8; also elsewhere on the board
OPC1: J801.6; also elsewhere on the board
OPC2: J801.4; also elsewhere on the board
OPC3: J801.2; also elsewhere on the board
OPR0: J802.8; also elsewhere on the board
OPR1: J802.6; also elsewhere on the board
OPR2: J802.4; also elsewhere on the board
OPR3: J802.2; also elsewhere on the board
OPR4: J803.8; also elsewhere on the board
OPR5: J803.6; also elsewhere on the board
OPR6: J803.4; also elsewhere on the board
OPR7: J803.2; also elsewhere on the board
OPR8: J804.8; also elsewhere on the board
OPR9: J804.6; also elsewhere on the board
OPR10: J804.4; also elsewhere on the board
OPR11: J804.2; also elsewhere on the board
VDD: J801.1, J802.1, J803.1, J804.1; also elsewhere on the board

Notes on the sheet:
7segIF x4

Parts:
C1101, C1102, C1103: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U1101: 6116; DIP-24_W15.24mm_Socket
U1102, U1103: 74HC244; DIP-20_W7.62mm_Socket

Connections:
A0: U1101.8 (A0); also elsewhere on the board
A1: U1101.7 (A1); also elsewhere on the board
A2: U1101.6 (A2); also elsewhere on the board
A3: U1101.5 (A3); also elsewhere on the board
A4: U1101.4 (A4); also elsewhere on the board
A5: U1101.3 (A5); also elsewhere on the board
A6: U1101.2 (A6); also elsewhere on the board
A7: U1101.1 (A7); also elsewhere on the board
GND: C1101.2, C1102.1, C1103.1, U1101.12 (GND), U1101.19 (A10), U1101.22 (A9), U1101.23 (A8), U1102.10 (GND), U1102.11 (2A3), U1102.13 (2A2), U1102.15 (2A1), U1102.17 (2A0), U1103.10 (GND); also elsewhere on the board
MD0: U1101.9 (D0), U1102.12 (1Y3), U1103.12 (1Y3); also elsewhere on the board
MD1: U1101.10 (D1), U1102.14 (1Y2), U1103.14 (1Y2); also elsewhere on the board
MD2: U1101.11 (D2), U1102.16 (1Y1), U1103.16 (1Y1); also elsewhere on the board
MD3: U1101.13 (D3), U1102.18 (1Y0), U1103.18 (1Y0); also elsewhere on the board
MD4: U1101.14 (D4), U1102.3 (2Y0), U1103.3 (2Y0); also elsewhere on the board
MD5: U1101.15 (D5), U1102.5 (2Y1), U1103.5 (2Y1); also elsewhere on the board
MD6: U1101.16 (D6), U1102.7 (2Y2), U1103.7 (2Y2); also elsewhere on the board
MD7: U1101.17 (D7), U1102.9 (2Y3), U1103.9 (2Y3); also elsewhere on the board
PC_Q0: U1103.8 (1A3); also elsewhere on the board
PC_Q1: U1103.6 (1A2); also elsewhere on the board
PC_Q2: U1103.4 (1A1); also elsewhere on the board
PC_Q3: U1103.2 (1A0); also elsewhere on the board
PC_Q4: U1103.17 (2A0); also elsewhere on the board
PC_Q5: U1103.15 (2A1); also elsewhere on the board
PC_Q6: U1103.13 (2A2); also elsewhere on the board
PC_Q7: U1103.11 (2A3); also elsewhere on the board
VDD: C1101.1, C1102.2, C1103.2, U1101.24 (VCC), U1102.20 (VCC), U1103.20 (VCC); also elsewhere on the board
WR: U1101.20 (~OE); also elsewhere on the board
YD0: U1102.8 (1A3); also elsewhere on the board
YD1: U1102.6 (1A2); also elsewhere on the board
YD2: U1102.4 (1A1); also elsewhere on the board
YD3: U1102.2 (1A0); also elsewhere on the board
~CS_RAM: U1101.18 (~CS); also elsewhere on the board
~WE_RAM: U1101.21 (~W); also elsewhere on the board
~YEN_PC: U1103.1 (1OE), U1103.19 (2OE); also elsewhere on the board
~YEN_Y: U1102.1 (1OE), U1102.19 (2OE); also elsewhere on the board

Schematic: addrMUX.kicad_sch

Parts:
C1401, C1402, C1403, C1404, C1407, C1408, C1409: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U1401: 74HC138; DIP-16_W7.62mm_Socket
U1402, U1403, U1404, U1405: 74HC244; DIP-20_W7.62mm_Socket
U1406: 74HC157; DIP-16_W7.62mm_Socket
U1407: 74HC139; DIP-16_W7.62mm_Socket

Connections:
A0: U1402.18 (1Y0), U1403.18 (1Y0), U1404.18 (1Y0), U1405.18 (1Y0); also elsewhere on the board
A1: U1402.14 (1Y2), U1403.16 (1Y1), U1404.16 (1Y1), U1405.16 (1Y1); also elsewhere on the board
A2: U1402.16 (1Y1), U1403.14 (1Y2), U1404.14 (1Y2), U1405.14 (1Y2); also elsewhere on the board
A3: U1402.12 (1Y3), U1403.12 (1Y3), U1404.12 (1Y3), U1405.12 (1Y3); also elsewhere on the board
A4: U1402.3 (2Y0), U1403.3 (2Y0), U1404.3 (2Y0), U1405.3 (2Y0); also elsewhere on the board
A5: U1402.5 (2Y1), U1403.5 (2Y1), U1404.5 (2Y1), U1405.5 (2Y1); also elsewhere on the board
A6: U1402.7 (2Y2), U1403.7 (2Y2), U1404.7 (2Y2), U1405.7 (2Y2); also elsewhere on the board
A7: U1402.9 (2Y3), U1403.9 (2Y3), U1404.9 (2Y3), U1405.9 (2Y3); also elsewhere on the board
EXE: U1401.6 (E2), U1403.1 (1OE), U1403.19 (2OE); also elsewhere on the board
GND: C1401.2, C1402.2, C1403.2, C1404.2, C1407.2, C1408.2, C1409.2, U1401.3 (A2), U1401.4 (~E0), U1401.5 (~E1), U1401.8 (GND), U1402.10 (GND), U1403.10 (GND), U1404.8 (1A3), U1404.10 (GND), U1405.10 (GND), U1406.8 (GND), U1406.10 (I1c), U1406.11 (I0c), U1406.13 (I1d), U1406.14 (I0d), U1406.15 (E), U1407.8 (GND); also elsewhere on the board
INPUT0: U1407.4 (O0); also elsewhere on the board
INPUT1: U1407.5 (O1); also elsewhere on the board
INPUT2: U1407.6 (O2); also elsewhere on the board
INPUT3: U1407.7 (O3); also elsewhere on the board
OPR4: U1402.2 (1A0), U1406.2 (I0a); also elsewhere on the board
OPR5: U1402.6 (1A2), U1406.5 (I0b); also elsewhere on the board
OPR6: U1402.4 (1A1); also elsewhere on the board
OPR7: U1402.8 (1A3); also elsewhere on the board
OPR8: U1402.17 (2A0), U1406.3 (I1a); also elsewhere on the board
OPR9: U1402.15 (2A1), U1406.6 (I1b); also elsewhere on the board
OPR10: U1402.13 (2A2); also elsewhere on the board
OPR11: U1402.11 (2A3); also elsewhere on the board
OUTPUT0: U1407.12 (O0); also elsewhere on the board
OUTPUT1: U1407.11 (O1); also elsewhere on the board
OUTPUT2: U1407.10 (O2); also elsewhere on the board
OUTPUT3: U1407.9 (O3); also elsewhere on the board
PC_Q0: U1403.2 (1A0); also elsewhere on the board
PC_Q1: U1403.4 (1A1); also elsewhere on the board
PC_Q2: U1403.6 (1A2); also elsewhere on the board
PC_Q3: U1403.8 (1A3); also elsewhere on the board
PC_Q4: U1403.17 (2A0); also elsewhere on the board
PC_Q5: U1403.15 (2A1); also elsewhere on the board
PC_Q6: U1403.13 (2A2); also elsewhere on the board
PC_Q7: U1403.11 (2A3); also elsewhere on the board
SEL_IMM: U1406.1 (S); also elsewhere on the board
SEL_M0: U1401.1 (A0), U1405.6 (1A2); also elsewhere on the board
SEL_M1: U1401.2 (A1); also elsewhere on the board
SP0: U1404.2 (1A0); also elsewhere on the board
SP1: U1404.4 (1A1); also elsewhere on the board
SP2: U1404.6 (1A2); also elsewhere on the board
VDD: C1401.1, C1402.1, C1403.1, C1404.1, C1407.1, C1408.1, C1409.1, U1401.16 (VCC), U1402.20 (VCC), U1403.20 (VCC), U1404.11 (2A3), U1404.13 (2A2), U1404.15 (2A1), U1404.17 (2A0), U1404.20 (VCC), U1405.8 (1A3), U1405.11 (2A3), U1405.13 (2A2), U1405.15 (2A1), U1405.17 (2A0), U1405.20 (VCC), U1406.16 (VCC), U1407.16 (VCC); also elsewhere on the board
port0: U1405.2 (1A0), U1406.4 (Za), U1407.2 (A0), U1407.14 (A0)
port1: U1405.4 (1A1), U1406.7 (Zb), U1407.3 (A1), U1407.13 (A1)
~OE_iAddr: U1401.13 (~Y2), U1407.1 (E)
~OE_ioAddr: U1405.1 (1OE), U1405.19 (2OE); also elsewhere on the board
~OE_mAddr: U1401.15 (~Y0), U1402.1 (1OE), U1402.19 (2OE)
~OE_oAddr: U1401.12 (~Y3), U1407.15 (E)
~OE_spAddr: U1401.14 (~Y1), U1404.1 (1OE), U1404.19 (2OE)

Notes on the sheet:
mAddr
I/Oチャネル指定用の244 他のアドレスを選択しないようにしている

Schematic: Decoder.kicad_sch

Parts:
C701, C702, C705, C706: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U701, U705: 74HC273; DIP-20_W7.62mm_Socket
U703, U706: 28C256; DIP-28_W15.24mm_Socket

Connections:
C_WE: U705.5 (Q1); also elsewhere on the board
DCR: U701.11 (Cp), U705.11 (Cp); also elsewhere on the board
GND: C701.1, C702.1, C705.1, C706.1, U701.10 (GND), U703.1 (A14), U703.2 (A12), U703.14 (GND), U703.20 (~CS), U703.21 (A10), U703.22 (~OE), U703.23 (A11), U703.26 (A13), U705.10 (GND), U706.1 (A14), U706.2 (A12), U706.14 (GND), U706.20 (~CS), U706.21 (A10), U706.22 (~OE), U706.23 (A11), U706.26 (A13); also elsewhere on the board
unnamed: U701.3 (D0), U703.11 (D0)
unnamed: U701.4 (D1), U703.12 (D1)
unnamed: U701.7 (D2), U703.13 (D2)
unnamed: U701.8 (D3), U703.15 (D3)
unnamed: U701.13 (D4), U703.16 (D4)
unnamed: U701.14 (D5), U703.17 (D5)
unnamed: U701.17 (D6), U703.18 (D6)
unnamed: U701.18 (D7), U703.19 (D7)
unnamed: U705.3 (D0), U706.11 (D0)
unnamed: U705.4 (D1), U706.12 (D1)
unnamed: U705.7 (D2), U706.13 (D2)
unnamed: U705.8 (D3), U706.15 (D3)
unnamed: U705.13 (D4), U706.16 (D4)
unnamed: U705.14 (D5), U706.17 (D5)
unnamed: U705.17 (D6), U706.18 (D6)
unnamed: U705.18 (D7), U706.19 (D7)
OPC0: U703.6 (A4), U706.6 (A4); also elsewhere on the board
OPC1: U703.5 (A5), U706.5 (A5); also elsewhere on the board
OPC2: U703.4 (A6), U706.4 (A6); also elsewhere on the board
OPC3: U703.3 (A7), U706.3 (A7); also elsewhere on the board
OPR0: U703.10 (A0), U706.10 (A0); also elsewhere on the board
OPR1: U703.9 (A1), U706.9 (A1); also elsewhere on the board
OPR2: U703.8 (A2), U706.8 (A2); also elsewhere on the board
OPR3: U703.7 (A3), U706.7 (A3); also elsewhere on the board
PC_LOAD: U701.15 (Q5); also elsewhere on the board
RegAddrSrc: U701.12 (Q4); also elsewhere on the board
SEL_M0: U701.5 (Q1); also elsewhere on the board
SEL_M1: U701.6 (Q2); also elsewhere on the board
SEL_PC: U701.9 (Q3); also elsewhere on the board
SEL_Y: U701.2 (Q0); also elsewhere on the board
SP_CD: U701.19 (Q7); also elsewhere on the board
SP_CU: U701.16 (Q6); also elsewhere on the board
VDD: C701.2, C702.2, C705.2, C706.2, U701.20 (VCC), U703.27 (~WE), U703.28 (VCC), U705.20 (VCC), U706.27 (~WE), U706.28 (VCC); also elsewhere on the board
WR: U705.9 (Q3); also elsewhere on the board
Z_WE: U705.6 (Q2); also elsewhere on the board
carry_in: U703.25 (A8), U706.25 (A8); also elsewhere on the board
zero_prev: U703.24 (A9), U706.24 (A9); also elsewhere on the board
~RST: U701.1 (~Mr), U705.1 (~Mr); also elsewhere on the board
~SEL_Y: U705.12 (Q4); also elsewhere on the board
~WE: U705.2 (Q0); also elsewhere on the board

Notes on the sheet:
デコーダ

Board: 2 copper layers, 210.0 x 170.0 mm, 101 parts (0 on the bottom side), 160 nets.
