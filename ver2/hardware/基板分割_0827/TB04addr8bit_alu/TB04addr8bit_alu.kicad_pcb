# Repository Myuu1967/TB-04 (continued)

## KiCad design ver2/hardware/TB04addr8bit_copy/TB04addr8bit_copy.kicad_pcb (continued)

Parts:
C1501, C1502, C1503, C1504, C1505, C1506, C1507: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U1501: 74AHC04; DIP-14_W7.62mm_Socket
U1503, U1507: 74HC08; DIP-14_W7.62mm_Socket
U1504, U1505: 74HC00; DIP-14_W7.62mm_Socket
U1506: 74HC32; DIP-14_W7.62mm_Socket
U1509: 74HC10; DIP-14_W7.62mm_Socket

Connections:
CD: U1504.3; also elsewhere on the board
CD_pre: U1504.2, U1507.6
CLK_C: U1503.3; also elsewhere on the board
CLK_CPU: U1506.13, U1509.13; also elsewhere on the board
CLK_Z: U1503.6; also elsewhere on the board
CS_RAM: U1501.13, U1505.9, U1507.11, U1509.1
CU: U1506.11; also elsewhere on the board
CU_pre: U1504.4, U1507.8
CU_raw: U1504.6, U1506.12
C_WE: U1503.2; also elsewhere on the board
DCR: U1504.5; also elsewhere on the board
EXE: U1503.13, U1504.1, U1504.10, U1505.13, U1507.13; also elsewhere on the board
FCH1: U1503.1, U1503.4, U1506.9; also elsewhere on the board
FCH2: U1506.10; also elsewhere on the board
GND: C1501.2, C1502.1, C1503.2, C1504.2, C1505.1, C1506.1, C1507.1, U1501.7 (GND), U1503.7 (GND), U1504.7 (GND), U1505.7 (GND), U1506.7 (GND), U1507.1, U1507.2, U1507.7 (GND), U1509.7 (GND), U1509.9, U1509.10, U1509.11; also elsewhere on the board
unnamed: U1506.3, U1506.4
OPR6: U1501.3; also elsewhere on the board
P2: U1501.1, U1503.9; also elsewhere on the board
P5: U1501.5; also elsewhere on the board
PC_CNT_EN: U1506.8; also elsewhere on the board
PC_LOAD: U1504.9; also elsewhere on the board
RAM_STK_SEL: U1503.8, U1507.12
ROM_SEL: U1501.2, U1504.12
SEL_M1: U1505.12; also elsewhere on the board
SEL_Y: U1505.5; also elsewhere on the board
SP0: U1506.1, U1509.3; also elsewhere on the board
SP1: U1506.2, U1509.4; also elsewhere on the board
SP2: U1506.5, U1509.5; also elsewhere on the board
SP_CD: U1507.4; also elsewhere on the board
SP_CU: U1507.9; also elsewhere on the board
SP_NE0: U1506.6, U1507.5
SP_NE7: U1507.10, U1509.6
VDD: C1501.1, C1502.2, C1503.1, C1504.1, C1505.2, C1506.2, C1507.2, U1501.14 (VCC), U1503.14 (VCC), U1504.14 (VCC), U1505.14 (VCC), U1506.14 (VCC), U1507.14 (VCC), U1509.14 (VCC); also elsewhere on the board
WR: U1503.12, U1509.2; also elsewhere on the board
WR_EXE: U1501.9, U1503.11, U1505.1, U1505.4
Z_WE: U1503.5; also elsewhere on the board
sel_a2: U1501.11; also elsewhere on the board
~CS_RAM: U1501.12; also elsewhere on the board
~Ena_RS01: U1501.10; also elsewhere on the board
~Enb_RS01: U1501.4; also elsewhere on the board
~OE_RAM: U1505.8; also elsewhere on the board
~OE_ROM: U1504.11; also elsewhere on the board
~OE_ioAddr: U1505.11; also elsewhere on the board
~P5: U1501.6, U1503.10
~PC_PE: U1504.8; also elsewhere on the board
~SEL_Y: U1505.2; also elsewhere on the board
~WE_RAM: U1509.12; also elsewhere on the board
~WR_EXE: U1501.8, U1504.13
~WR: U1505.10; also elsewhere on the board
~YEN_PC: U1505.6; also elsewhere on the board
~YEN_Y: U1505.3; also elsewhere on the board

Notes on the sheet:
ROM_SEL=~{A7&A6}
A7=A6=0 ~{WE}=1のとき~{OE}=0
SP=7のときそれ以上 カウントアップさせない
SP=0のときそれ以下に カウントダウンさせない

Parts:
C401, C402, C403, C404, C405, C406, C407, C408: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC401, IC402: 74HC161N; DIP-16_W7.62mm_Socket; Manufacturer_Part_Number 74HC161N
U401, U404: 74LS157; DIP-16_W7.62mm_Socket
U402, U403, U405, U406: 74LS253; DIP-16_W7.62mm_Socket

Connections:
CLK_CPU: IC401.2 (CP), IC402.2 (CP); also elsewhere on the board
DOa0: U402.5 (I1a), U402.6 (I0a); also elsewhere on the board
DOa1: U402.10 (I0b), U402.11 (I1b); also elsewhere on the board
DOa2: U405.5 (I1a), U405.6 (I0a); also elsewhere on the board
DOa3: U405.10 (I0b), U405.11 (I1b); also elsewhere on the board
DOb0: U403.6 (I0a); also elsewhere on the board
DOb1: U403.10 (I0b); also elsewhere on the board
DOb2: U406.6 (I0a); also elsewhere on the board
DOb3: U406.10 (I0b); also elsewhere on the board
GND: C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, IC401.8 (GND), IC402.8 (GND), U401.8 (GND), U401.15 (E), U402.1 (OEa), U402.8 (GND), U402.15 (OEb), U403.1 (OEa), U403.3 (I3a), U403.8 (GND), U403.13 (I3b), U403.15 (OEb), U404.8 (GND), U404.15 (E), U405.1 (OEa), U405.8 (GND), U405.15 (OEb), U406.1 (OEa), U406.3 (I3a), U406.8 (GND), U406.13 (I3b), U406.15 (OEb); also elsewhere on the board
MD0: U401.3 (I1a), U403.5 (I1a); also elsewhere on the board
MD1: U401.6 (I1b), U403.11 (I1b); also elsewhere on the board
MD2: U401.10 (I1c), U406.5 (I1a); also elsewhere on the board
MD3: U401.13 (I1d), U406.11 (I1b); also elsewhere on the board
MD4: U404.3 (I1a); also elsewhere on the board
MD5: U404.6 (I1b); also elsewhere on the board
MD6: U404.10 (I1c); also elsewhere on the board
MD7: U404.13 (I1d); also elsewhere on the board
unnamed: IC401.10 (CET), IC402.15 (TC)
OPR0: U402.4 (I2a); also elsewhere on the board
OPR1: U402.12 (I2b); also elsewhere on the board
OPR2: U405.4 (I2a); also elsewhere on the board
OPR3: U405.12 (I2b); also elsewhere on the board
OPR4: U401.2 (I0a), U402.3 (I3a), U403.4 (I2a); also elsewhere on the board
OPR5: U401.5 (I0b), U402.13 (I3b), U403.12 (I2b); also elsewhere on the board
OPR6: U401.11 (I0c), U405.3 (I3a), U406.4 (I2a); also elsewhere on the board
OPR7: U401.14 (I0d), U405.13 (I3b), U406.12 (I2b); also elsewhere on the board
OPR8: U404.2 (I0a); also elsewhere on the board
OPR9: U404.5 (I0b); also elsewhere on the board
OPR10: U404.11 (I0c); also elsewhere on the board
OPR11: U404.14 (I0d); also elsewhere on the board
PC0: IC402.3 (D0), U401.4 (Za)
PC1: IC402.4 (D1), U401.7 (Zb)
PC2: IC402.5 (D2), U401.9 (Zc)
PC3: IC402.6 (D3), U401.12 (Zd)
PC4: IC401.3 (D0), U404.4 (Za)
PC5: IC401.4 (D1), U404.7 (Zb)
PC6: IC401.5 (D2), U404.9 (Zc)
PC7: IC401.6 (D3), U404.12 (Zd)
PC_CNT_EN: IC401.7 (CEP), IC402.7 (CEP), IC402.10 (CET); also elsewhere on the board
PC_Q0: IC402.14 (Q0); also elsewhere on the board
PC_Q1: IC402.13 (Q1); also elsewhere on the board
PC_Q2: IC402.12 (Q2); also elsewhere on the board
PC_Q3: IC402.11 (Q3); also elsewhere on the board
PC_Q4: IC401.14 (Q0); also elsewhere on the board
PC_Q5: IC401.13 (Q1); also elsewhere on the board
PC_Q6: IC401.12 (Q2); also elsewhere on the board
PC_Q7: IC401.11 (Q3); also elsewhere on the board
SEL_A: U402.2 (A1), U405.2 (A1); also elsewhere on the board
SEL_B0: U403.14 (A0), U406.14 (A0); also elsewhere on the board
SEL_B1: U403.2 (A1), U406.2 (A1); also elsewhere on the board
SEL_IMM: U402.14 (A0), U405.14 (A0); also elsewhere on the board
SEL_PC: U401.1 (S), U404.1 (S); also elsewhere on the board
VDD: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, IC401.16 (VCC), IC402.16 (VCC), U401.16 (VCC), U402.16 (VCC), U403.16 (VCC), U404.16 (VCC), U405.16 (VCC), U406.16 (VCC); also elsewhere on the board
alu_a0: U402.7 (Za); also elsewhere on the board
alu_a1: U402.9 (Zb); also elsewhere on the board
alu_a2: U405.7 (Za); also elsewhere on the board
alu_a3: U405.9 (Zb); also elsewhere on the board
alu_b0: U403.7 (Za); also elsewhere on the board
alu_b1: U403.9 (Zb); also elsewhere on the board
alu_b2: U406.7 (Za); also elsewhere on the board
alu_b3: U406.9 (Zb); also elsewhere on the board
~PC_PE: IC401.9 (~PE), IC402.9 (~PE); also elsewhere on the board
~RST: IC401.1 (~MR), IC402.1 (~MR); also elsewhere on the board

Notes on the sheet:
PC_L
mAddrH
PC_H

Parts:
J801, J802, J803, J804, J805, J806, J807, J808: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical

Connections:
GND: J801.9, J801.10, J802.9, J802.10, J803.9, J803.10, J804.9, J804.10, J805.9, J805.10, J806.9, J806.10, J807.9, J807.10, J808.9, J808.10; also elsewhere on the board
MD0: J805.8; also elsewhere on the board
MD1: J805.6; also elsewhere on the board
MD2: J805.4; also elsewhere on the board
MD3: J805.2; also elsewhere on the board
MD4: J806.8; also elsewhere on the board
MD5: J806.6; also elsewhere on the board
MD6: J806.4; also elsewhere on the board
MD7: J806.2; also elsewhere on the board
OPC0: J801.8; also elsewhere on the board
OPC1: J801.6; also elsewhere on the board
OPC2: J801.4; also elsewhere on the board
OPC3: J801.2; also elsewhere on the board
OPR0: J802.8; also elsewhere on the board
OPR1: J802.6; also elsewhere on the board
OPR2: J802.4; also elsewhere on the board
OPR3: J802.2; also elsewhere on the board
OPR4: J803.8; also elsewhere on the board
OPR5: J803.6; also elsewhere on the board
OPR6: J803.4; also elsewhere on the board
OPR7: J803.2; also elsewhere on the board
OPR8: J804.8; also elsewhere on the board
OPR9: J804.6; also elsewhere on the board
OPR10: J804.4; also elsewhere on the board
OPR11: J804.2; also elsewhere on the board
PC_Q0: J807.8; also elsewhere on the board
PC_Q1: J807.6; also elsewhere on the board
PC_Q2: J807.4; also elsewhere on the board
PC_Q3: J807.2; also elsewhere on the board
PC_Q4: J808.8; also elsewhere on the board
PC_Q5: J808.6; also elsewhere on the board
PC_Q6: J808.4; also elsewhere on the board
PC_Q7: J808.2; also elsewhere on the board
VDD: J801.1, J802.1, J803.1, J804.1, J805.1, J806.1, J807.1, J808.1; also elsewhere on the board

Notes on the sheet:
7segIF x4
7segIF x2

Schematic: RS01.kicad_sch

Parts:
C301, C302, C303, C304, C305, C306, C307, C308: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC301, IC302, IC303, IC304: 74HC161N; DIP-16_W7.62mm_Socket; Manufacturer_Part_Number 74HC161N
J301, J302, J303, J304: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
U301, U302, U303, U304: 74LS253; DIP-16_W7.62mm_Socket

Connections:
/RS01/I0a0: IC301.14 (Q0), J302.8, U301.6 (I0a), U303.6 (I0a); also elsewhere on the board
/RS01/I0a1: IC302.14 (Q0), J301.8, U301.5 (I1a), U303.5 (I1a); also elsewhere on the board
/RS01/I0a2: IC303.14 (Q0), J303.8, U301.4 (I2a), U303.4 (I2a); also elsewhere on the board
/RS01/I0a3: IC304.14 (Q0), J304.8, U301.3 (I3a), U303.3 (I3a); also elsewhere on the board
/RS01/I0b0: IC301.13 (Q1), J302.6, U301.10 (I0b), U303.10 (I0b); also elsewhere on the board
/RS01/I0b1: IC302.13 (Q1), J301.6, U301.11 (I1b), U303.11 (I1b); also elsewhere on the board
/RS01/I0b2: IC303.13 (Q1), J303.6, U301.12 (I2b), U303.12 (I2b); also elsewhere on the board
/RS01/I0b3: IC304.13 (Q1), J304.6, U301.13 (I3b), U303.13 (I3b); also elsewhere on the board
/RS01/I1a0: IC301.12 (Q2), J302.4, U302.6 (I0a), U304.6 (I0a); also elsewhere on the board
/RS01/I1a1: IC302.12 (Q2), J301.4, U302.5 (I1a), U304.5 (I1a); also elsewhere on the board
/RS01/I1a2: IC303.12 (Q2), J303.4, U302.4 (I2a), U304.4 (I2a); also elsewhere on the board
/RS01/I1a3: IC304.12 (Q2), J304.4, U302.3 (I3a), U304.3 (I3a); also elsewhere on the board
/RS01/I1b0: IC301.11 (Q3), J302.2, U302.10 (I0b), U304.10 (I0b); also elsewhere on the board
/RS01/I1b1: IC302.11 (Q3), J301.2, U302.11 (I1b), U304.11 (I1b); also elsewhere on the board
/RS01/I1b2: IC303.11 (Q3), J303.2, U302.12 (I2b), U304.12 (I2b); also elsewhere on the board
/RS01/I1b3: IC304.11 (Q3), J304.2, U302.13 (I3b), U304.13 (I3b); also elsewhere on the board
CLK_CPU: IC301.2 (CP), IC302.2 (CP), IC303.2 (CP), IC304.2 (CP); also elsewhere on the board
DI0: IC301.3 (D0), IC302.3 (D0), IC303.3 (D0), IC304.3 (D0); also elsewhere on the board
DI1: IC301.4 (D1), IC302.4 (D1), IC303.4 (D1), IC304.4 (D1); also elsewhere on the board
DI2: IC301.5 (D2), IC302.5 (D2), IC303.5 (D2), IC304.5 (D2); also elsewhere on the board
DI3: IC301.6 (D3), IC302.6 (D3), IC303.6 (D3), IC304.6 (D3); also elsewhere on the board
DOa0: U301.7 (Za); also elsewhere on the board
DOa1: U301.9 (Zb); also elsewhere on the board
DOa2: U302.7 (Za); also elsewhere on the board
DOa3: U302.9 (Zb); also elsewhere on the board
DOb0: U303.7 (Za); also elsewhere on the board
DOb1: U303.9 (Zb); also elsewhere on the board
DOb2: U304.7 (Za); also elsewhere on the board
DOb3: U304.9 (Zb); also elsewhere on the board
GND: C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, IC301.7 (CEP), IC301.8 (GND), IC301.10 (CET), IC302.7 (CEP), IC302.8 (GND), IC302.10 (CET), IC303.7 (CEP), IC303.8 (GND), IC303.10 (CET), IC304.7 (CEP), IC304.8 (GND), IC304.10 (CET), J301.9, J301.10, J302.9, J302.10, J303.9, J303.10, J304.9, J304.10, U301.8 (GND), U302.8 (GND), U303.8 (GND), U304.8 (GND); also elsewhere on the board
OPR4: U303.14 (A0), U304.14 (A0); also elsewhere on the board
OPR5: U303.2 (A1), U304.2 (A1); also elsewhere on the board
VDD: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, IC301.16 (VCC), IC302.16 (VCC), IC303.16 (VCC), IC304.16 (VCC), J301.1, J302.1, J303.1, J304.1, U301.16 (VCC), U302.16 (VCC), U303.16 (VCC), U304.16 (VCC); also elsewhere on the board
sel_a0: U301.14 (A0), U302.14 (A0); also elsewhere on the board
sel_a1: U301.2 (A1), U302.2 (A1); also elsewhere on the board
~Ena_RS01: U301.1 (OEa), U301.15 (OEb), U302.1 (OEa), U302.15 (OEb); also elsewhere on the board
~Enb_RS01: U303.1 (OEa), U303.15 (OEb), U304.1 (OEa), U304.15 (OEb); also elsewhere on the board
~RST: IC301.1 (~MR), IC302.1 (~MR), IC303.1 (~MR), IC304.1 (~MR); also elsewhere on the board
~Reg_WE4: IC301.9 (~PE); also elsewhere on the board
~Reg_WE5: IC302.9 (~PE); also elsewhere on the board
~Reg_WE6: IC303.9 (~PE); also elsewhere on the board
~Reg_WE7: IC304.9 (~PE); also elsewhere on the board

Notes on the sheet:
Reg5
Reg4
Reg7
7segIF x4
Reg6

Schematic: clk_rst.kicad_sch

Parts:
C501, C502: 10u 16V; CP_Radial_D5.0mm_P2.00mm
C503, C504: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C505, C506: 22p; C_Disc_D4.3mm_W1.9mm_P5.00mm
D501, D502: LED; LED_D3.0mm_Clear
H501, H502, H503, H504: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
R501, R502: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R503, R506: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R504, R507, R509: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R505: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R508, R510: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R511: 10M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R512: 220K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW501, SW503: SW_Push; SW_Tactile_Straight_KSL0Axx1LFTR
SW502: sw rotary; SW_Rotary_1x9_Alpha_SR1712F-0109
U501: 74HC14; DIP-14_W7.62mm_Socket
U502: 4060; DIP-16_W7.62mm_Socket
Y501: 32.768KHz; DIP-8_W7.62mm_Socket

Connections:
CLK_CPU: U501.8, U501.11; also elsewhere on the board
GND: C501.2, C502.2, C503.1, C504.2, C505.2, C506.2, D501.1 (K), D502.1 (K), H501.1 (1_1), H502.1 (1_1), H503.1 (1_1), H504.1 (1_1), R509.2, SW501.1, SW503.1, U501.7 (GND), U501.13, U502.8 (VSS); also elsewhere on the board
unnamed: C501.1, R503.2, R504.1
unnamed: C502.1, R506.2, R507.1
unnamed: D501.2 (A), R508.2
unnamed: D502.2 (A), R510.2
unnamed: R501.2, R503.1, SW501.2
unnamed: R502.2, R506.1, SW503.2
unnamed: R504.2, U501.5
unnamed: R505.1, U501.6
unnamed: R505.2, SW502.2
unnamed: R507.2, U501.1
unnamed: R509.1, R510.1, SW502.1, U501.9
unnamed: R512.1, Y501.2
unnamed: SW502.10, U502.7 (Q4)
unnamed: SW502.9, U502.5 (Q5)
unnamed: SW502.8, U502.4 (Q6)
unnamed: SW502.7, U502.14 (Q8)
unnamed: SW502.6, U502.13 (Q9)
unnamed: SW502.5, U502.15 (Q10)
unnamed: SW502.4, U502.1 (Q12)
unnamed: SW502.3, U502.2 (Q13)
unnamed: C506.1, R511.2, R512.2, U502.11 (~Φ1)
unnamed: C505.1, R511.1, U502.10 (Φ0), Y501.1
RST: R508.1, U501.2, U501.3, U502.12 (CLR)
VDD: C503.2, C504.1, R501.1, R502.1, U501.14 (VCC), U502.16 (VDD); also elsewhere on the board
~CLK_CPU: U501.10; also elsewhere on the board
~RST: U501.4; also elsewhere on the board

Notes on the sheet:
Auto
Manual
Slow
Fast

Schematic: RS00.kicad_sch

Parts:
C201, C202, C203, C204, C205, C206, C207, C208: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212, D213, D214, D215, D216: LED; LED_D3.0mm_Clear
IC201, IC202, IC203, IC204: 74HC161N; DIP-16_W7.62mm_Socket; Manufacturer_Part_Number 74HC161N
RN201, RN202: 4.7K; R_Array_SIP9
U201, U202, U203, U204: 74LS253; DIP-16_W7.62mm_Socket

Connections:
/RS00/I0a0: D216.2 (A), IC201.14 (Q0), U201.6 (I0a), U203.6 (I0a)
/RS00/I0a1: D208.2 (A), IC202.14 (Q0), U201.5 (I1a), U203.5 (I1a)
/RS00/I0a2: D215.2 (A), IC203.14 (Q0), U201.4 (I2a), U203.4 (I2a)
/RS00/I0a3: D207.2 (A), IC204.14 (Q0), U201.3 (I3a), U203.3 (I3a)
/RS00/I0b0: D214.2 (A), IC201.13 (Q1), U201.10 (I0b), U203.10 (I0b)
/RS00/I0b1: D206.2 (A), IC202.13 (Q1), U201.11 (I1b), U203.11 (I1b)
/RS00/I0b2: D213.2 (A), IC203.13 (Q1), U201.12 (I2b), U203.12 (I2b)
/RS00/I0b3: D205.2 (A), IC204.13 (Q1), U201.13 (I3b), U203.13 (I3b)
/RS00/I1a0: D212.2 (A), IC201.12 (Q2), U202.6 (I0a), U204.6 (I0a)
/RS00/I1a1: D204.2 (A), IC202.12 (Q2), U202.5 (I1a), U204.5 (I1a)
/RS00/I1a2: D211.2 (A), IC203.12 (Q2), U202.4 (I2a), U204.4 (I2a)
/RS00/I1a3: D203.2 (A), IC204.12 (Q2), U202.3 (I3a), U204.3 (I3a)
/RS00/I1b0: D210.2 (A), IC201.11 (Q3), U202.10 (I0b), U204.10 (I0b)
/RS00/I1b1: D202.2 (A), IC202.11 (Q3), U202.11 (I1b), U204.11 (I1b)
/RS00/I1b2: D209.2 (A), IC203.11 (Q3), U202.12 (I2b), U204.12 (I2b)
/RS00/I1b3: D201.2 (A), IC204.11 (Q3), U202.13 (I3b), U204.13 (I3b)
CLK_CPU: IC201.2 (CP), IC202.2 (CP), IC203.2 (CP), IC204.2 (CP); also elsewhere on the board
DI0: IC201.3 (D0), IC202.3 (D0), IC203.3 (D0), IC204.3 (D0); also elsewhere on the board
DI1: IC201.4 (D1), IC202.4 (D1), IC203.4 (D1), IC204.4 (D1); also elsewhere on the board
DI2: IC201.5 (D2), IC202.5 (D2), IC203.5 (D2), IC204.5 (D2); also elsewhere on the board
DI3: IC201.6 (D3), IC202.6 (D3), IC203.6 (D3), IC204.6 (D3); also elsewhere on the board
DOa0: U201.7 (Za); also elsewhere on the board
DOa1: U201.9 (Zb); also elsewhere on the board
DOa2: U202.7 (Za); also elsewhere on the board
DOa3: U202.9 (Zb); also elsewhere on the board
DOb0: U203.7 (Za); also elsewhere on the board
DOb1: U203.9 (Zb); also elsewhere on the board
DOb2: U204.7 (Za); also elsewhere on the board
DOb3: U204.9 (Zb); also elsewhere on the board
GND: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, IC201.7 (CEP), IC201.8 (GND), IC201.10 (CET), IC202.7 (CEP), IC202.8 (GND), IC202.10 (CET), IC203.7 (CEP), IC203.8 (GND), IC203.10 (CET), IC204.7 (CEP), IC204.8 (GND), IC204.10 (CET), RN201.1 (common), RN202.1 (common), U201.8 (GND), U202.8 (GND), U203.8 (GND), U204.8 (GND); also elsewhere on the board
unnamed: D201.1 (K), RN201.2 (R1)
unnamed: D202.1 (K), RN202.2 (R1)
unnamed: D203.1 (K), RN201.3 (R2)
unnamed: D204.1 (K), RN202.3 (R2)
unnamed: D205.1 (K), RN201.4 (R3)
unnamed: D206.1 (K), RN202.4 (R3)
unnamed: D207.1 (K), RN201.5 (R4)
unnamed: D208.1 (K), RN202.5 (R4)
unnamed: D209.1 (K), RN201.6 (R5)
unnamed: D210.1 (K), RN202.6 (R5)
unnamed: D211.1 (K), RN201.7 (R6)
unnamed: D212.1 (K), RN202.7 (R6)
unnamed: D213.1 (K), RN201.8 (R7)
unnamed: D214.1 (K), RN202.8 (R7)
unnamed: D215.1 (K), RN201.9 (R8)
unnamed: D216.1 (K), RN202.9 (R8)
OPR4: U203.14 (A0), U204.14 (A0); also elsewhere on the board
OPR5: U203.2 (A1), U204.2 (A1); also elsewhere on the board
OPR6: U203.1 (OEa), U203.15 (OEb), U204.1 (OEa), U204.15 (OEb); also elsewhere on the board
VDD: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, IC201.16 (VCC), IC202.16 (VCC), IC203.16 (VCC), IC204.16 (VCC), U201.16 (VCC), U202.16 (VCC), U203.16 (VCC), U204.16 (VCC); also elsewhere on the board
sel_a0: U201.14 (A0), U202.14 (A0); also elsewhere on the board
sel_a1: U201.2 (A1), U202.2 (A1); also elsewhere on the board
sel_a2: U201.1 (OEa), U201.15 (OEb), U202.1 (OEa), U202.15 (OEb); also elsewhere on the board
~RST: IC201.1 (~MR), IC202.1 (~MR), IC203.1 (~MR), IC204.1 (~MR); also elsewhere on the board
~Reg_WE0: IC201.9 (~PE); also elsewhere on the board
~Reg_WE1: IC202.9 (~PE); also elsewhere on the board
~Reg_WE2: IC203.9 (~PE); also elsewhere on the board
~Reg_WE3: IC204.9 (~PE); also elsewhere on the board

Notes on the sheet:
7segIF x4
Reg3
Reg2
Reg0
Reg1

Schematic: inPut.kicad_sch

Parts:
C1001, C1002, C1003, C1004: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1001, D1002, D1003, D1004, D1005, D1006, D1007, D1008, D1009, D1010, D1011, D1012, D1013, D1014, D1015, D1016: LED; LED_D3.0mm_Clear
J1001, J1002, J1003, J1004: Conn_01x06_Socket; PinSocket_1x06_P2.54mm_Vertical
R1001, R1002, R1003, R1004, R1005, R1006, R1007, R1008, R1009, R1010, R1011, R1012, R1013, R1014, R1015, R1016: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1002, RN1003, RN1005, RN1007: 4.7K; R_Array_SIP5
RN1009, RN1010: 10K; R_Array_SIP9
SW1001, SW1002, SW1003, SW1004: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
U1001, U1002, U1003, U1004: 74HC244; DIP-20_W7.62mm_Socket

Connections:
GND: C1001.1, C1002.1, C1003.1, C1004.1, J1001.6, J1002.6, J1003.6, J1004.6, RN1002.1 (common), RN1003.1 (common), RN1005.1 (common), RN1007.1 (common), RN1009.1 (R1), RN1010.1 (R1), U1001.10 (GND), U1001.11 (2A3), U1001.13 (2A2), U1001.15 (2A1), U1001.17 (2A0), U1002.10 (GND), U1002.11 (2A3), U1002.13 (2A2), U1002.15 (2A1), U1002.17 (2A0), U1003.10 (GND), U1003.11 (2A3), U1003.13 (2A2), U1003.15 (2A1), U1003.17 (2A0), U1004.10 (GND), U1004.11 (2A3), U1004.13 (2A2), U1004.15 (2A1), U1004.17 (2A0); also elsewhere on the board
IN0_0: D1001.2 (A), J1001.4, RN1009.5 (R4.2), SW1001.4, U1001.2 (1A0)
IN0_1: D1003.2 (A), J1001.3, RN1009.4 (R3.2), SW1001.3, U1001.4 (1A1)
IN0_2: D1002.2 (A), J1001.2, RN1009.3 (R2.2), SW1001.2, U1001.6 (1A2)
IN0_3: D1004.2 (A), J1001.1, RN1009.2 (R1.2), SW1001.1, U1001.8 (1A3)
IN1_0: D1005.2 (A), J1002.4, RN1009.9 (R8.2), SW1002.4, U1002.2 (1A0)
IN1_1: D1006.2 (A), J1002.3, RN1009.8 (R7.2), SW1002.3, U1002.4 (1A1)
IN1_2: D1007.2 (A), J1002.2, RN1009.7 (R6.2), SW1002.2, U1002.6 (1A2)
IN1_3: D1008.2 (A), J1002.1, RN1009.6 (R5.2), SW1002.1, U1002.8 (1A3)
IN2_0: D1009.2 (A), J1003.4, RN1010.5 (R4.2), SW1003.4, U1003.2 (1A0)
IN2_1: D1010.2 (A), J1003.3, RN1010.4 (R3.2), SW1003.3, U1003.4 (1A1)
IN2_2: D1011.2 (A), J1003.2, RN1010.3 (R2.2), SW1003.2, U1003.6 (1A2)
IN2_3: D1012.2 (A), J1003.1, RN1010.2 (R1.2), SW1003.1, U1003.8 (1A3)
IN3_0: D1013.2 (A), J1004.4, RN1010.9 (R8.2), SW1004.4, U1004.2 (1A0)
IN3_1: D1014.2 (A), J1004.3, RN1010.8 (R7.2), SW1004.3, U1004.4 (1A1)
IN3_2: D1015.2 (A), J1004.2, RN1010.7 (R6.2), SW1004.2, U1004.6 (1A2)
IN3_3: D1016.2 (A), J1004.1, RN1010.6 (R5.2), SW1004.1, U1004.8 (1A3)
INPUT0: U1001.1 (1OE), U1001.19 (2OE); also elsewhere on the board
INPUT1: U1002.1 (1OE), U1002.19 (2OE); also elsewhere on the board
INPUT2: U1003.1 (1OE), U1003.19 (2OE); also elsewhere on the board
INPUT3: U1004.1 (1OE), U1004.19 (2OE); also elsewhere on the board
MD0: U1001.18 (1Y0), U1002.18 (1Y0), U1003.18 (1Y0), U1004.18 (1Y0); also elsewhere on the board
MD1: U1001.16 (1Y1), U1002.16 (1Y1), U1003.16 (1Y1), U1004.16 (1Y1); also elsewhere on the board
MD2: U1001.14 (1Y2), U1002.14 (1Y2), U1003.14 (1Y2), U1004.14 (1Y2); also elsewhere on the board
MD3: U1001.12 (1Y3), U1002.12 (1Y3), U1003.12 (1Y3), U1004.12 (1Y3); also elsewhere on the board
MD4: U1001.3 (2Y0), U1002.3 (2Y0), U1003.3 (2Y0), U1004.3 (2Y0); also elsewhere on the board
MD5: U1001.5 (2Y1), U1002.5 (2Y1), U1003.5 (2Y1), U1004.5 (2Y1); also elsewhere on the board
MD6: U1001.7 (2Y2), U1002.7 (2Y2), U1003.7 (2Y2), U1004.7 (2Y2); also elsewhere on the board
MD7: U1001.9 (2Y3), U1002.9 (2Y3), U1003.9 (2Y3), U1004.9 (2Y3); also elsewhere on the board
unnamed: D1001.1 (K), RN1002.5 (R4)
unnamed: D1002.1 (K), RN1002.3 (R2)
unnamed: D1003.1 (K), RN1002.4 (R3)
unnamed: D1004.1 (K), RN1002.2 (R1)
unnamed: D1005.1 (K), RN1003.5 (R4)
unnamed: D1006.1 (K), RN1003.4 (R3)
unnamed: D1007.1 (K), RN1003.3 (R2)
unnamed: D1008.1 (K), RN1003.2 (R1)
unnamed: D1009.1 (K), RN1005.5 (R4)
unnamed: D1010.1 (K), RN1005.4 (R3)
unnamed: D1011.1 (K), RN1005.3 (R2)
unnamed: D1012.1 (K), RN1005.2 (R1)
unnamed: D1013.1 (K), RN1007.5 (R4)
unnamed: D1014.1 (K), RN1007.4 (R3)
unnamed: D1015.1 (K), RN1007.3 (R2)
unnamed: D1016.1 (K), RN1007.2 (R1)
unnamed: R1001.2, SW1004.8
unnamed: R1002.2, SW1004.7
unnamed: R1003.2, SW1004.6
unnamed: R1004.2, SW1004.5
unnamed: R1005.2, SW1001.8
unnamed: R1006.2, SW1001.7
unnamed: R1007.2, SW1001.6
unnamed: R1008.2, SW1001.5
unnamed: R1009.2, SW1002.8
unnamed: R1010.2, SW1002.7
unnamed: R1011.2, SW1002.6
unnamed: R1012.2, SW1002.5
unnamed: R1013.2, SW1003.8
unnamed: R1014.2, SW1003.7
unnamed: R1015.2, SW1003.6
unnamed: R1016.2, SW1003.5
VDD: C1001.2, C1002.2, C1003.2, C1004.2, J1001.5, J1002.5, J1003.5, J1004.5, R1001.1, R1002.1, R1003.1, R1004.1, R1005.1, R1006.1, R1007.1, R1008.1, R1009.1, R1010.1, R1011.1, R1012.1, R1013.1, R1014.1, R1015.1, R1016.1, U1001.20 (VCC), U1002.20 (VCC), U1003.20 (VCC), U1004.20 (VCC); also elsewhere on the board
