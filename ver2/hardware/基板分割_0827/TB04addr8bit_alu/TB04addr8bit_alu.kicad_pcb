# Repository Myuu1967/TB-04 (continued)

## KiCad design ver2/hardware/基板分割_0827/TB04addr8bit_alu/TB04addr8bit_alu.kicad_pcb (continued)

Parts:
C201, C202, C203, C204, C205, C206, C207, C208: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212, D213, D214, D215, D216: LED; LED_D3.0mm_Clear
IC201, IC202, IC203, IC204: 74HC161N; DIP-16_W7.62mm_Socket; Manufacturer_Part_Number 74HC161N
RN201, RN202: 4.7K; R_Array_SIP9
U201, U202, U203, U204: 74HC253; DIP-16_W7.62mm_Socket

Connections:
/RS00/I0a0: D216.2 (A), IC201.14 (Q0), U201.6 (I0a), U203.6 (I0a)
/RS00/I0a1: D208.2 (A), IC202.14 (Q0), U201.5 (I1a), U203.5 (I1a)
/RS00/I0a2: D215.2 (A), IC203.14 (Q0), U201.4 (I2a), U203.4 (I2a)
/RS00/I0a3: D207.2 (A), IC204.14 (Q0), U201.3 (I3a), U203.3 (I3a)
/RS00/I0b0: D214.2 (A), IC201.13 (Q1), U201.10 (I0b), U203.10 (I0b)
/RS00/I0b1: D206.2 (A), IC202.13 (Q1), U201.11 (I1b), U203.11 (I1b)
/RS00/I0b2: D213.2 (A), IC203.13 (Q1), U201.12 (I2b), U203.12 (I2b)
/RS00/I0b3: D205.2 (A), IC204.13 (Q1), U201.13 (I3b), U203.13 (I3b)
/RS00/I1a0: D212.2 (A), IC201.12 (Q2), U202.6 (I0a), U204.6 (I0a)
/RS00/I1a1: D204.2 (A), IC202.12 (Q2), U202.5 (I1a), U204.5 (I1a)
/RS00/I1a2: D211.2 (A), IC203.12 (Q2), U202.4 (I2a), U204.4 (I2a)
/RS00/I1a3: D203.2 (A), IC204.12 (Q2), U202.3 (I3a), U204.3 (I3a)
/RS00/I1b0: D210.2 (A), IC201.11 (Q3), U202.10 (I0b), U204.10 (I0b)
/RS00/I1b1: D202.2 (A), IC202.11 (Q3), U202.11 (I1b), U204.11 (I1b)
/RS00/I1b2: D209.2 (A), IC203.11 (Q3), U202.12 (I2b), U204.12 (I2b)
/RS00/I1b3: D201.2 (A), IC204.11 (Q3), U202.13 (I3b), U204.13 (I3b)
CLK_CPU: IC201.2 (CP), IC202.2 (CP), IC203.2 (CP), IC204.2 (CP); also elsewhere on the board
DI0: IC201.3 (D0), IC202.3 (D0), IC203.3 (D0), IC204.3 (D0); also elsewhere on the board
DI1: IC201.4 (D1), IC202.4 (D1), IC203.4 (D1), IC204.4 (D1); also elsewhere on the board
DI2: IC201.5 (D2), IC202.5 (D2), IC203.5 (D2), IC204.5 (D2); also elsewhere on the board
DI3: IC201.6 (D3), IC202.6 (D3), IC203.6 (D3), IC204.6 (D3); also elsewhere on the board
DOa0: U201.7 (Za); also elsewhere on the board
DOa1: U201.9 (Zb); also elsewhere on the board
DOa2: U202.7 (Za); also elsewhere on the board
DOa3: U202.9 (Zb); also elsewhere on the board
DOb0: U203.7 (Za); also elsewhere on the board
DOb1: U203.9 (Zb); also elsewhere on the board
DOb2: U204.7 (Za); also elsewhere on the board
DOb3: U204.9 (Zb); also elsewhere on the board
GND: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, IC201.7 (CEP), IC201.8 (GND), IC201.10 (CET), IC202.7 (CEP), IC202.8 (GND), IC202.10 (CET), IC203.7 (CEP), IC203.8 (GND), IC203.10 (CET), IC204.7 (CEP), IC204.8 (GND), IC204.10 (CET), RN201.1 (common), RN202.1 (common), U201.8 (GND), U202.8 (GND), U203.8 (GND), U204.8 (GND); also elsewhere on the board
unnamed: D201.1 (K), RN201.6 (R5)
unnamed: D202.1 (K), RN202.6 (R5)
unnamed: D203.1 (K), RN201.7 (R6)
unnamed: D204.1 (K), RN202.7 (R6)
unnamed: D205.1 (K), RN201.8 (R7)
unnamed: D206.1 (K), RN202.8 (R7)
unnamed: D207.1 (K), RN201.9 (R8)
unnamed: D208.1 (K), RN202.9 (R8)
unnamed: D209.1 (K), RN201.2 (R1)
unnamed: D210.1 (K), RN202.2 (R1)
unnamed: D211.1 (K), RN201.3 (R2)
unnamed: D212.1 (K), RN202.3 (R2)
unnamed: D213.1 (K), RN201.4 (R3)
unnamed: D214.1 (K), RN202.4 (R3)
unnamed: D215.1 (K), RN201.5 (R4)
unnamed: D216.1 (K), RN202.5 (R4)
OPR4: U203.14 (A0), U204.14 (A0); also elsewhere on the board
OPR5: U203.2 (A1), U204.2 (A1); also elsewhere on the board
OPR6: U203.1 (OEa), U203.15 (OEb), U204.1 (OEa), U204.15 (OEb); also elsewhere on the board
VDD: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, IC201.16 (VCC), IC202.16 (VCC), IC203.16 (VCC), IC204.16 (VCC), U201.16 (VCC), U202.16 (VCC), U203.16 (VCC), U204.16 (VCC); also elsewhere on the board
sel_a0: U201.14 (A0), U202.14 (A0); also elsewhere on the board
sel_a1: U201.2 (A1), U202.2 (A1); also elsewhere on the board
sel_a2: U201.1 (OEa), U201.15 (OEb), U202.1 (OEa), U202.15 (OEb); also elsewhere on the board
~RST: IC201.1 (~MR), IC202.1 (~MR), IC203.1 (~MR), IC204.1 (~MR); also elsewhere on the board
~Reg_WE0: IC201.9 (~PE); also elsewhere on the board
~Reg_WE1: IC202.9 (~PE); also elsewhere on the board
~Reg_WE2: IC203.9 (~PE); also elsewhere on the board
~Reg_WE3: IC204.9 (~PE); also elsewhere on the board

Notes on the sheet:
7segIF x4
Reg3
Reg2
Reg0
Reg1

Parts:
C703, C704: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U702: 74HC273; DIP-20_W7.62mm_Socket
U704: 28C256; DIP-28_W15.24mm_Socket

Connections:
DCR: U702.11 (Cp); also elsewhere on the board
GND: C703.1, C704.1, U702.10 (GND), U704.1 (A14), U704.2 (A12), U704.14 (GND), U704.20 (~CS), U704.21 (A10), U704.22 (~OE), U704.23 (A11), U704.26 (A13); also elsewhere on the board
unnamed: U702.3 (D0), U704.11 (D0)
unnamed: U702.4 (D1), U704.12 (D1)
unnamed: U702.7 (D2), U704.13 (D2)
unnamed: U702.8 (D3), U704.15 (D3)
unnamed: U702.13 (D4), U704.16 (D4)
unnamed: U702.14 (D5), U704.17 (D5)
unnamed: U702.17 (D6), U704.18 (D6)
unnamed: U702.18 (D7), U704.19 (D7)
OPC0: U704.6 (A4); also elsewhere on the board
OPC1: U704.5 (A5); also elsewhere on the board
OPC2: U704.4 (A6); also elsewhere on the board
OPC3: U704.3 (A7); also elsewhere on the board
OPR0: U704.10 (A0); also elsewhere on the board
OPR1: U704.9 (A1); also elsewhere on the board
OPR2: U704.8 (A2); also elsewhere on the board
OPR3: U704.7 (A3); also elsewhere on the board
SEL_A: U702.12 (Q4); also elsewhere on the board
SEL_B0: U702.15 (Q5); also elsewhere on the board
SEL_B1: U702.16 (Q6); also elsewhere on the board
SEL_IMM: U702.19 (Q7); also elsewhere on the board
VDD: C703.2, C704.2, U702.20 (VCC), U704.27 (~WE), U704.28 (VCC); also elsewhere on the board
alu_code0: U702.2 (Q0); also elsewhere on the board
alu_code1: U702.5 (Q1); also elsewhere on the board
alu_code2: U702.6 (Q2); also elsewhere on the board
alu_code3: U702.9 (Q3); also elsewhere on the board
carry_in: U704.25 (A8); also elsewhere on the board
zero_prev: U704.24 (A9); also elsewhere on the board
~RST: U702.1 (~Mr); also elsewhere on the board

Notes on the sheet:
デコーダ

Board: 2 copper layers, 130.0 x 150.0 mm, 102 parts (0 on the bottom side), 145 nets.

## KiCad design ver2/hardware/基板分割_0827/TB04addr8bit_ctrl/TB04addr8bit_ctrl.kicad_pcb

Parts:
C101, C103: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C104: 100u; CP_Radial_D5.0mm_P2.00mm
D101: LED; LED_D3.0mm_Clear
H101, H102, H103, H104, H105, H106: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J2: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
J3: Conn_02x10_Odd_Even; PinSocket_2x10_P2.54mm_Vertical
J6, J7, J8, J9: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
J1602: Screw_Terminal_01x02; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
R103: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U101: 74HC157; DIP-16_W7.62mm_Socket

Connections:
CLK_C: J2.9; also elsewhere on the board
CLK_CPU: J1.1, J2.1; also elsewhere on the board
CLK_Z: J2.11; also elsewhere on the board
DCR: J2.5; also elsewhere on the board
DI0: J2.27; also elsewhere on the board
DI1: J2.25; also elsewhere on the board
DI2: J2.23; also elsewhere on the board
DI3: J2.21; also elsewhere on the board
EXE: J2.7; also elsewhere on the board
GND: C101.2, C103.2, C104.2, D101.1 (K), H101.1 (1_1), H102.1 (1_1), H103.1 (1_1), H104.1 (1_1), H105.1 (1_1), H106.1 (1_1), J1.2, J1.4, J1.6, J1.8, J1.10, J1.12, J1.14, J1.16, J1.18, J1.20, J1.22, J1.24, J1.26, J1.28, J1.30, J1.32, J1.34, J1.36, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J2.22, J2.24, J2.26, J2.28, J2.30, J2.32, J2.34, J2.36, J3.1, J3.6, J3.11, J3.16, J3.20, J6.9, J6.10, J7.9, J7.10, J8.9, J8.10, J9.9, J9.10, J1602.2, U101.8 (GND), U101.13 (I1d), U101.14 (I0d), U101.15 (E); also elsewhere on the board
INPUT0: J1.27; also elsewhere on the board
INPUT1: J1.25; also elsewhere on the board
INPUT2: J1.23; also elsewhere on the board
INPUT3: J1.21; also elsewhere on the board
MD0: J1.19, J2.19, J7.8; also elsewhere on the board
MD1: J1.17, J2.17, J7.6; also elsewhere on the board
MD2: J1.15, J2.15, J7.4; also elsewhere on the board
MD3: J1.13, J2.13, J7.2; also elsewhere on the board
MD4: J1.11, J6.8; also elsewhere on the board
MD5: J1.9, J6.6; also elsewhere on the board
MD6: J1.7, J6.4; also elsewhere on the board
MD7: J1.5, J6.2; also elsewhere on the board
unnamed: D101.2 (A), R103.2
OPC0: J3.5; also elsewhere on the board
OPC1: J3.4; also elsewhere on the board
OPC2: J3.3; also elsewhere on the board
OPC3: J3.2; also elsewhere on the board
OPR0: J3.15, U101.3 (I1a); also elsewhere on the board
OPR1: J3.14, U101.10 (I1c); also elsewhere on the board
OPR2: J3.13, U101.6 (I1b); also elsewhere on the board
OPR3: J3.12; also elsewhere on the board
OPR4: J3.10; also elsewhere on the board
OPR5: J3.9; also elsewhere on the board
OPR6: J3.8; also elsewhere on the board
OPR7: J3.7; also elsewhere on the board
OPR8: U101.2 (I0a); also elsewhere on the board
OPR9: U101.11 (I0c); also elsewhere on the board
OPR10: U101.5 (I0b); also elsewhere on the board
OUTPUT0: J1.35; also elsewhere on the board
OUTPUT1: J1.33; also elsewhere on the board
OUTPUT2: J1.31; also elsewhere on the board
OUTPUT3: J1.29; also elsewhere on the board
PC_Q0: J9.8; also elsewhere on the board
PC_Q1: J9.6; also elsewhere on the board
PC_Q2: J9.4; also elsewhere on the board
PC_Q3: J9.2; also elsewhere on the board
PC_Q4: J8.8; also elsewhere on the board
PC_Q5: J8.6; also elsewhere on the board
PC_Q6: J8.4; also elsewhere on the board
PC_Q7: J8.2; also elsewhere on the board
RegAddrSrc: U101.1 (S); also elsewhere on the board
SEL_IMM: J3.17; also elsewhere on the board
VDD: C101.1, C103.1, C104.1, J1.38, J1.40, J2.38, J2.40, J6.1, J7.1, J8.1, J9.1, J1602.1, R103.1, U101.16 (VCC); also elsewhere on the board
carry_in: J2.29; also elsewhere on the board
sel_a0: J2.37, U101.4 (Za)
sel_a1: J2.35, U101.9 (Zc)
sel_a2: J2.33, U101.7 (Zb); also elsewhere on the board
zero_prev: J2.31; also elsewhere on the board
~Ena_RS01: J3.18; also elsewhere on the board
~Enb_RS01: J3.19; also elsewhere on the board
~RST: J1.3, J2.3; also elsewhere on the board
~WE: J2.39; also elsewhere on the board

Parts:
C602, C603, C604, C605, C606, C607: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D603, D604, D605, D606: LED; LED_D3.0mm_Clear
IC601: 74HC161N; DIP-16_W7.62mm_Socket; Manufacturer_Part_Number 74HC161N
RN601: 4.7K; R_Array_SIP5
RN602: 10K; R_Array_SIP5
SW601: SW_Coded_SH-7050; dip_rotary_sw
U601, U602, U606: 74HC273; DIP-20_W7.62mm_Socket
U604: 28C256; DIP_Socket-28_W11.9mm_W12.7mm_W15.24mm_W17.78mm_W18.5mm_3M_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
U607: 74HC238; DIP-16_W7.62mm_Socket

Connections:
A0: U604.10 (A0); also elsewhere on the board
A1: U604.9 (A1); also elsewhere on the board
A2: U604.8 (A2); also elsewhere on the board
A3: U604.7 (A3); also elsewhere on the board
A4: U604.6 (A4); also elsewhere on the board
A5: U604.5 (A5); also elsewhere on the board
A6: U604.4 (A6); also elsewhere on the board
A7: U604.3 (A7); also elsewhere on the board
CLK_CPU: IC601.2 (CP); also elsewhere on the board
DCR: D604.2 (A), U606.11 (Cp), U607.13 (Y2); also elsewhere on the board
DI0: U601.3 (D0); also elsewhere on the board
DI1: U601.4 (D1); also elsewhere on the board
DI2: U601.7 (D2); also elsewhere on the board
DI3: U601.8 (D3); also elsewhere on the board
EXE: D606.2 (A), U601.11 (Cp), U607.12 (Y3); also elsewhere on the board
FCH1: D603.2 (A), U607.15 (Y0); also elsewhere on the board
FCH2: D605.2 (A), U602.11 (Cp), U607.14 (Y1); also elsewhere on the board
GND: C602.1, C603.1, C604.1, C605.1, C606.2, C607.2, IC601.3 (D0), IC601.4 (D1), IC601.5 (D2), IC601.6 (D3), IC601.8 (GND), RN601.1 (common), RN602.1 (common), U601.10 (GND), U601.13 (D4), U601.14 (D5), U601.17 (D6), U601.18 (D7), U602.10 (GND), U604.1 (A14), U604.2 (A12), U604.14 (GND), U604.20 (~CS), U604.26 (A13), U606.10 (GND), U607.3 (A2), U607.4 (~E1), U607.5 (~E2), U607.8 (GND); also elsewhere on the board
MD0: U602.3 (D0), U604.11 (D0), U606.3 (D0); also elsewhere on the board
MD1: U602.4 (D1), U604.12 (D1), U606.4 (D1); also elsewhere on the board
MD2: U602.7 (D2), U604.13 (D2), U606.7 (D2); also elsewhere on the board
MD3: U602.8 (D3), U604.15 (D3), U606.8 (D3); also elsewhere on the board
MD4: U602.13 (D4), U604.16 (D4), U606.13 (D4); also elsewhere on the board
MD5: U602.14 (D5), U604.17 (D5), U606.14 (D5); also elsewhere on the board
MD6: U602.17 (D6), U604.18 (D6), U606.17 (D6); also elsewhere on the board
MD7: U602.18 (D7), U604.19 (D7), U606.18 (D7); also elsewhere on the board
unnamed: D603.1 (K), RN601.5 (R4)
unnamed: D604.1 (K), RN601.3 (R2)
unnamed: D605.1 (K), RN601.4 (R3)
unnamed: D606.1 (K), RN601.2 (R1)
unnamed: IC601.14 (Q0), U607.1 (A0)
unnamed: IC601.13 (Q1), U607.2 (A1)
unnamed: RN602.2 (R1), SW601.8, U604.23 (A11)
unnamed: RN602.3 (R2), SW601.4, U604.21 (A10)
unnamed: RN602.4 (R3), SW601.2, U604.24 (A9)
unnamed: RN602.5 (R4), SW601.1, U604.25 (A8)
OPC0: U602.12 (Q4); also elsewhere on the board
OPC1: U602.15 (Q5); also elsewhere on the board
OPC2: U602.16 (Q6); also elsewhere on the board
OPC3: U602.19 (Q7); also elsewhere on the board
OPR0: U602.2 (Q0); also elsewhere on the board
OPR1: U602.5 (Q1); also elsewhere on the board
OPR2: U602.6 (Q2); also elsewhere on the board
OPR3: U602.9 (Q3); also elsewhere on the board
OPR4: U606.2 (Q0); also elsewhere on the board
OPR5: U606.5 (Q1); also elsewhere on the board
OPR6: U606.6 (Q2); also elsewhere on the board
OPR7: U606.9 (Q3); also elsewhere on the board
OPR8: U606.12 (Q4); also elsewhere on the board
OPR9: U606.15 (Q5); also elsewhere on the board
OPR10: U606.16 (Q6); also elsewhere on the board
OPR11: U606.19 (Q7); also elsewhere on the board
VDD: C602.2, C603.2, C604.2, C605.2, C606.1, C607.1, IC601.7 (CEP), IC601.9 (~PE), IC601.10 (CET), IC601.16 (VCC), SW601.C, U601.20 (VCC), U602.20 (VCC), U604.27 (~WE), U604.28 (VCC), U606.20 (VCC), U607.6 (E3), U607.16 (VCC); also elsewhere on the board
YD0: U601.2 (Q0); also elsewhere on the board
YD1: U601.5 (Q1); also elsewhere on the board
YD2: U601.6 (Q2); also elsewhere on the board
YD3: U601.9 (Q3); also elsewhere on the board
~OE_ROM: U604.22 (~OE); also elsewhere on the board
~RST: IC601.1 (~MR), U601.1 (~Mr), U602.1 (~Mr), U606.1 (~Mr); also elsewhere on the board

Notes on the sheet:
命令ROM
フェーズ発生器
正論理
carry_outと zero_flag

Parts:
C1201: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1201, D1202, D1203: LED; LED_D3.0mm_Clear
R1201, R1202, R1203: 4.7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1201: 74HC193; DIP-16_W7.62mm_Socket

Connections:
CD: U1201.4 (DOWN); also elsewhere on the board
CU: U1201.5 (UP); also elsewhere on the board
GND: C1201.2, D1201.1 (K), D1202.1 (K), D1203.1 (K), U1201.8 (GND), U1201.9 (D), U1201.14 (CLR); also elsewhere on the board
unnamed: D1201.2 (A), R1201.2
unnamed: D1202.2 (A), R1202.2
unnamed: D1203.2 (A), R1203.2
SP0: R1203.1, U1201.3 (QA); also elsewhere on the board
SP1: R1202.1, U1201.2 (QB); also elsewhere on the board
SP2: R1201.1, U1201.6 (QC); also elsewhere on the board
VDD: C1201.1, U1201.1 (B), U1201.10 (C), U1201.15 (A), U1201.16 (VCC); also elsewhere on the board
~RST: U1201.11 (~LOAD); also elsewhere on the board

Notes on the sheet:
bit2 bit1 bit0

Notices in the files:
peripherals/7segIF/hardware/7segIF.kicad_pcb:
License: CC BY-SA 4.0 (https://creativecommons.org/licenses/by-sa/4.0/)
Based on / adapted from cherry-takuan (ちぇりーたくあん), CC BY-SA 4.0
Changes were made. This unit is also released under CC BY-SA 4.0.
