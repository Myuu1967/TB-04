# Repository Myuu1967/TB-04 (continued)

## KiCad design ver2/hardware/基板分割_0827/TB04_carry/TB04_carry.kicad_pcb

Parts:
C1: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C2: 100u; CP_Radial_D5.0mm_P2.00mm
D1: LED; LED_D3.0mm_Clear
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J2: Conn_02x10_Odd_Even; PinSocket_2x10_P2.54mm_Vertical
J3, J4, J5, J6: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
J1602: Screw_Terminal_01x02; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
R1: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
DIG_D0_0: J2.6, J3.8
DIG_D0_1: J2.5, J3.6
DIG_D0_2: J2.4, J3.4
DIG_D0_3: J2.3, J3.2
DIG_D1_0: J2.10, J4.8
DIG_D1_1: J2.9, J4.6
DIG_D1_2: J2.8, J4.4
DIG_D1_3: J2.7, J4.2
DIG_D2_0: J2.14, J5.8
DIG_D2_1: J2.13, J5.6
DIG_D2_2: J2.12, J5.4
DIG_D2_3: J2.11, J5.2
DIG_D3_0: J2.18, J6.8
DIG_D3_1: J2.17, J6.6
DIG_D3_2: J2.16, J6.4
DIG_D3_3: J2.15, J6.2
GND: C1.2, C2.2, D1.1 (K), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J2.2, J2.19, J3.9, J3.10, J4.9, J4.10, J5.9, J5.10, J6.9, J6.10, J1602.2
unnamed: D1.2 (A), R1.2
VDD: C1.1, C2.1, J2.1, J3.1, J4.1, J5.1, J6.1, J1602.1, R1.1

Board: 2 copper layers, 100.0 x 30.0 mm, 14 parts (0 on the bottom side), 19 nets.

## KiCad design ver2/hardware/TB04addr8bit_copy/TB04addr8bit_copy.kicad_pcb

Parts:
C101, C102, C103: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C104: 100u; CP_Radial_D5.0mm_P2.00mm
D101: LED; LED_D3.0mm_Clear
J101: USB_C_Receptacle_PowerOnly_6P; USB_C_receptacle_onlypower_tanuki
R101, R102: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R103: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW101: SW_SPDT; sw_slide
U101: 74LS157; DIP-16_W7.62mm_Socket
U102: 74HC138; DIP-16_W7.62mm_Socket

Connections:
EXE: U102.6 (E2); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, D101.1 (K), J101.1 (B_12_GND), J101.6 (A12_GND), R101.1, R102.1, U101.8 (GND), U101.13 (I1d), U101.14 (I0d), U101.15 (E), U102.5 (~E1), U102.8 (GND); also elsewhere on the board
unnamed: D101.2 (A), R103.2
unnamed: J101.3 (A5_CC1), R102.2
unnamed: J101.2 (B9_VBUS), J101.5 (A9_VBUS), SW101.2 (B)
unnamed: J101.4 (B5_CC2), R101.2
OPR0: U101.3 (I1a); also elsewhere on the board
OPR1: U101.6 (I1b); also elsewhere on the board
OPR2: U101.10 (I1c); also elsewhere on the board
OPR8: U101.2 (I0a); also elsewhere on the board
OPR9: U101.5 (I0b); also elsewhere on the board
OPR10: U101.11 (I0c); also elsewhere on the board
RegAddrSrc: U101.1 (S); also elsewhere on the board
VDD: C101.1, C102.1, C103.1, C104.1, R103.1, SW101.3 (C), U101.16 (VCC), U102.16 (VCC); also elsewhere on the board
sel_a0: U101.4 (Za), U102.1 (A0); also elsewhere on the board
sel_a1: U101.7 (Zb), U102.2 (A1); also elsewhere on the board
sel_a2: U101.9 (Zc), U102.3 (A2); also elsewhere on the board
~Reg_WE0: U102.15 (~Y0); also elsewhere on the board
~Reg_WE1: U102.14 (~Y1); also elsewhere on the board
~Reg_WE2: U102.13 (~Y2); also elsewhere on the board
~Reg_WE3: U102.12 (~Y3); also elsewhere on the board
~Reg_WE4: U102.11 (~Y4); also elsewhere on the board
~Reg_WE5: U102.10 (~Y5); also elsewhere on the board
~Reg_WE6: U102.9 (~Y6); also elsewhere on the board
~Reg_WE7: U102.7 (~Y7); also elsewhere on the board
~WE: U102.4 (~E0); also elsewhere on the board

Parts:
C601, C602, C603, C604, C605, C606, C607, C608: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D601, D602, D603, D604, D605, D606: LED; LED_D3.0mm_Clear
IC601: 74HC161N; DIP-16_W7.62mm_Socket; Manufacturer_Part_Number 74HC161N
J601: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
R601, R602: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R603, R604, R605, R606: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN601: 4.7K; R_Array_SIP5
SW601: SW_Coded_SH-7050; dip_rotary_sw
U601, U602, U606: 74HC273; DIP-20_W7.62mm_Socket
U603: 28C256; DIP-28_W15.24mm_Socket
U604: 28C256; DIP_Socket-28_W11.9mm_W12.7mm_W15.24mm_W17.78mm_W18.5mm_3M_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
U605: 74HC74; DIP-14_W7.62mm_Socket
U607: 74HC238; DIP-16_W7.62mm_Socket

Connections:
A0: U604.10 (A0); also elsewhere on the board
A1: U604.9 (A1); also elsewhere on the board
A2: U604.8 (A2); also elsewhere on the board
A3: U604.7 (A3); also elsewhere on the board
A4: U604.6 (A4); also elsewhere on the board
A5: U604.5 (A5); also elsewhere on the board
A6: U604.4 (A6); also elsewhere on the board
A7: U604.3 (A7); also elsewhere on the board
CLK_C: U605.3 (C); also elsewhere on the board
CLK_CPU: IC601.2 (CP); also elsewhere on the board
CLK_Z: U605.11 (C); also elsewhere on the board
DCR: D604.2 (A), U606.11 (Cp), U607.13 (Y2); also elsewhere on the board
DI0: U601.3 (D0), U603.11 (D0); also elsewhere on the board
DI1: U601.4 (D1), U603.12 (D1); also elsewhere on the board
DI2: U601.7 (D2), U603.13 (D2); also elsewhere on the board
DI3: U601.8 (D3), U603.15 (D3); also elsewhere on the board
EXE: D606.2 (A), U601.11 (Cp), U607.12 (Y3); also elsewhere on the board
FCH1: D603.2 (A), U607.15 (Y0); also elsewhere on the board
FCH2: D605.2 (A), U602.11 (Cp), U607.14 (Y1); also elsewhere on the board
GND: C601.1, C602.1, C603.1, C604.1, C605.1, C606.2, C607.2, C608.2, D601.1 (K), D602.1 (K), IC601.3 (D0), IC601.4 (D1), IC601.5 (D2), IC601.6 (D3), IC601.8 (GND), J601.9, J601.10, R603.1, R604.1, R605.1, R606.1, RN601.1 (common), U601.10 (GND), U601.13 (D4), U601.14 (D5), U601.17 (D6), U601.18 (D7), U602.10 (GND), U603.1 (A14), U603.14 (GND), U603.20 (~CS), U603.22 (~OE), U603.26 (A13), U604.1 (A14), U604.2 (A12), U604.14 (GND), U604.20 (~CS), U604.26 (A13), U605.7 (GND), U606.10 (GND), U607.3 (A2), U607.4 (~E1), U607.5 (~E2), U607.8 (GND); also elsewhere on the board
MD0: U602.3 (D0), U604.11 (D0), U606.3 (D0); also elsewhere on the board
MD1: U602.4 (D1), U604.12 (D1), U606.4 (D1); also elsewhere on the board
MD2: U602.7 (D2), U604.13 (D2), U606.7 (D2); also elsewhere on the board
MD3: U602.8 (D3), U604.15 (D3), U606.8 (D3); also elsewhere on the board
MD4: U602.13 (D4), U604.16 (D4), U606.13 (D4); also elsewhere on the board
MD5: U602.14 (D5), U604.17 (D5), U606.14 (D5); also elsewhere on the board
MD6: U602.17 (D6), U604.18 (D6), U606.17 (D6); also elsewhere on the board
MD7: U602.18 (D7), U604.19 (D7), U606.18 (D7); also elsewhere on the board
unnamed: D601.2 (A), R601.2
unnamed: D602.2 (A), R602.2
unnamed: D603.1 (K), RN601.5 (R4)
unnamed: D604.1 (K), RN601.3 (R2)
unnamed: D605.1 (K), RN601.4 (R3)
unnamed: D606.1 (K), RN601.2 (R1)
unnamed: IC601.14 (Q0), U607.1 (A0)
unnamed: IC601.13 (Q1), U607.2 (A1)
unnamed: R603.2, SW601.1, U604.25 (A8)
unnamed: R604.2, SW601.2, U604.24 (A9)
unnamed: R605.2, SW601.4, U604.21 (A10)
unnamed: R606.2, SW601.8, U604.23 (A11)
OPC0: U602.12 (Q4); also elsewhere on the board
OPC1: U602.15 (Q5); also elsewhere on the board
OPC2: U602.16 (Q6); also elsewhere on the board
OPC3: U602.19 (Q7); also elsewhere on the board
OPR0: U602.2 (Q0); also elsewhere on the board
OPR1: U602.5 (Q1); also elsewhere on the board
OPR2: U602.6 (Q2); also elsewhere on the board
OPR3: U602.9 (Q3); also elsewhere on the board
OPR4: U606.2 (Q0); also elsewhere on the board
OPR5: U606.5 (Q1); also elsewhere on the board
OPR6: U606.6 (Q2); also elsewhere on the board
OPR7: U606.9 (Q3); also elsewhere on the board
OPR8: U606.12 (Q4); also elsewhere on the board
OPR9: U606.15 (Q5); also elsewhere on the board
OPR10: U606.16 (Q6); also elsewhere on the board
OPR11: U606.19 (Q7); also elsewhere on the board
VDD: C601.2, C602.2, C603.2, C604.2, C605.2, C606.1, C607.1, C608.1, IC601.7 (CEP), IC601.9 (~PE), IC601.10 (CET), IC601.16 (VCC), J601.1, SW601.C, U601.20 (VCC), U602.20 (VCC), U603.27 (~WE), U603.28 (VCC), U604.27 (~WE), U604.28 (VCC), U605.1 (~R), U605.4 (~S), U605.10 (~S), U605.13 (~R), U605.14 (VCC), U606.20 (VCC), U607.6 (E3), U607.16 (VCC); also elsewhere on the board
YD0: U601.2 (Q0); also elsewhere on the board
YD1: U601.5 (Q1); also elsewhere on the board
YD2: U601.6 (Q2); also elsewhere on the board
YD3: U601.9 (Q3); also elsewhere on the board
alu_a0: U603.10 (A0); also elsewhere on the board
alu_a1: U603.9 (A1); also elsewhere on the board
alu_a2: U603.8 (A2); also elsewhere on the board
alu_a3: U603.7 (A3); also elsewhere on the board
alu_b0: U603.6 (A4); also elsewhere on the board
alu_b1: U603.5 (A5); also elsewhere on the board
alu_b2: U603.4 (A6); also elsewhere on the board
alu_b3: U603.3 (A7); also elsewhere on the board
alu_code0: J601.8, U603.25 (A8); also elsewhere on the board
alu_code1: J601.6, U603.24 (A9); also elsewhere on the board
alu_code2: J601.4, U603.21 (A10); also elsewhere on the board
alu_code3: J601.2, U603.23 (A11); also elsewhere on the board
carry_in: R601.1, U603.2 (A12), U605.5 (Q); also elsewhere on the board
carry_out: U603.16 (D4), U605.2 (D)
zero_flag: U603.17 (D5), U605.12 (D)
zero_prev: R602.1, U605.9 (Q); also elsewhere on the board
~OE_ROM: U604.22 (~OE); also elsewhere on the board
~RST: IC601.1 (~MR), U601.1 (~Mr), U602.1 (~Mr), U606.1 (~Mr); also elsewhere on the board

Notes on the sheet:
命令ROM
フェーズ発生器
正論理
carry_outと zero_flag
ALU

Parts:
C901, C902, C903, C904: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D901, D902, D903, D904, D905, D906, D907, D908, D909, D910, D911, D912, D913, D914, D915, D916: LED; LED_D3.0mm_Clear
J901, J902, J903, J904: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
RN901, RN902, RN903, RN904: 4.7K; R_Array_SIP5
U901, U902, U903, U905: 74LS377; DIP-20_W7.62mm_Socket

Connections:
GND: C901.1, C902.1, C903.1, C904.1, J901.9, J901.10, J902.9, J902.10, J903.9, J903.10, J904.9, J904.10, RN901.1 (common), RN902.1 (common), RN903.1 (common), RN904.1 (common), U901.10 (GND), U901.13 (D4), U901.14 (D5), U901.17 (D6), U901.18 (D7), U902.10 (GND), U902.13 (D4), U902.14 (D5), U902.17 (D6), U902.18 (D7), U903.10 (GND), U903.13 (D4), U903.14 (D5), U903.17 (D6), U903.18 (D7), U905.10 (GND), U905.13 (D4), U905.14 (D5), U905.17 (D6), U905.18 (D7); also elsewhere on the board
MD0: U901.3 (D0), U902.3 (D0), U903.3 (D0), U905.3 (D0); also elsewhere on the board
MD1: U901.4 (D1), U902.4 (D1), U903.4 (D1), U905.4 (D1); also elsewhere on the board
MD2: U901.7 (D2), U902.7 (D2), U903.7 (D2), U905.7 (D2); also elsewhere on the board
MD3: U901.8 (D3), U902.8 (D3), U903.8 (D3), U905.8 (D3); also elsewhere on the board
unnamed: D901.2 (A), J901.2, U905.9 (Q3)
unnamed: D901.1 (K), RN901.5 (R4)
unnamed: D902.2 (A), J901.6, U905.5 (Q1)
unnamed: D902.1 (K), RN901.3 (R2)
unnamed: D903.2 (A), J901.4, U905.6 (Q2)
unnamed: D903.1 (K), RN901.4 (R3)
unnamed: D904.2 (A), J901.8, U905.2 (Q0)
unnamed: D904.1 (K), RN901.2 (R1)
unnamed: D905.2 (A), J902.2, U901.9 (Q3)
unnamed: D905.1 (K), RN902.5 (R4)
unnamed: D906.2 (A), J902.4, U901.6 (Q2)
unnamed: D906.1 (K), RN902.4 (R3)
unnamed: D907.2 (A), J902.6, U901.5 (Q1)
unnamed: D907.1 (K), RN902.3 (R2)
unnamed: D908.2 (A), J902.8, U901.2 (Q0)
unnamed: D908.1 (K), RN902.2 (R1)
unnamed: D909.2 (A), J903.2, U902.9 (Q3)
unnamed: D909.1 (K), RN903.5 (R4)
unnamed: D910.2 (A), J903.4, U902.6 (Q2)
unnamed: D910.1 (K), RN903.4 (R3)
unnamed: D911.2 (A), J903.6, U902.5 (Q1)
unnamed: D911.1 (K), RN903.3 (R2)
unnamed: D912.2 (A), J903.8, U902.2 (Q0)
unnamed: D912.1 (K), RN903.2 (R1)
unnamed: D913.2 (A), J904.2, U903.9 (Q3)
unnamed: D913.1 (K), RN904.5 (R4)
unnamed: D914.2 (A), J904.4, U903.6 (Q2)
unnamed: D914.1 (K), RN904.4 (R3)
unnamed: D915.2 (A), J904.6, U903.5 (Q1)
unnamed: D915.1 (K), RN904.3 (R2)
unnamed: D916.2 (A), J904.8, U903.2 (Q0)
unnamed: D916.1 (K), RN904.2 (R1)
OUTPUT0: U905.1 (~E); also elsewhere on the board
OUTPUT1: U901.1 (~E); also elsewhere on the board
OUTPUT2: U902.1 (~E); also elsewhere on the board
OUTPUT3: U903.1 (~E); also elsewhere on the board
VDD: C901.2, C902.2, C903.2, C904.2, J901.1, J902.1, J903.1, J904.1, U901.20 (VCC), U902.20 (VCC), U903.20 (VCC), U905.20 (VCC); also elsewhere on the board
~CLK_CPU: U901.11 (CP), U902.11 (CP), U903.11 (CP), U905.11 (CP); also elsewhere on the board

Parts:
C1201: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1201, D1202, D1203: LED; LED_D3.0mm_Clear
R1201, R1202, R1203: 4.7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1201: 74HC193; DIP-16_W7.62mm_Socket

Connections:
CD: U1201.4 (DOWN); also elsewhere on the board
CU: U1201.5 (UP); also elsewhere on the board
GND: C1201.2, D1201.1 (K), D1202.1 (K), D1203.1 (K), U1201.8 (GND), U1201.9 (D), U1201.14 (CLR); also elsewhere on the board
unnamed: D1201.2 (A), R1201.2
unnamed: D1202.2 (A), R1202.2
unnamed: D1203.2 (A), R1203.2
SP0: R1203.1, U1201.3 (QA); also elsewhere on the board
SP1: R1202.1, U1201.2 (QB); also elsewhere on the board
SP2: R1201.1, U1201.6 (QC); also elsewhere on the board
VDD: C1201.1, U1201.1 (B), U1201.10 (C), U1201.15 (A), U1201.16 (VCC); also elsewhere on the board
~RST: U1201.11 (~LOAD); also elsewhere on the board

Notes on the sheet:
bit2 bit1 bit0

Parts:
C1301: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U1301: 74LS08; DIP-14_W7.62mm_Socket

Connections:
A3: U1301.13; also elsewhere on the board
A4: U1301.5; also elsewhere on the board
A5: U1301.4; also elsewhere on the board
A6: U1301.2; also elsewhere on the board
A7: U1301.1; also elsewhere on the board
GND: C1301.2, U1301.7 (GND); also elsewhere on the board
unnamed: U1301.6, U1301.10
P2: U1301.3, U1301.9; also elsewhere on the board
P4: U1301.8, U1301.12
P5: U1301.11; also elsewhere on the board
VDD: C1301.1, U1301.14 (VCC); also elsewhere on the board
