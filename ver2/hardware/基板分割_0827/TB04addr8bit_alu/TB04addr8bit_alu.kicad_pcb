# Repository Myuu1967/TB-04 (continued)

## KiCad design ver2/hardware/TB04addr8bit_copy/TB04addr8bit_copy.kicad_pcb (continued)

Schematic: ram.kicad_sch

Parts:
C1101, C1102, C1103: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U1101: 6116; DIP-24_18.0mmx34.29mm_W15.24mm_Socket
U1102, U1103: 74HC244; DIP-20_W7.62mm_Socket

Connections:
A0: U1101.8 (A0); also elsewhere on the board
A1: U1101.7 (A1); also elsewhere on the board
A2: U1101.6 (A2); also elsewhere on the board
A3: U1101.5 (A3); also elsewhere on the board
A4: U1101.4 (A4); also elsewhere on the board
A5: U1101.3 (A5); also elsewhere on the board
A6: U1101.2 (A6); also elsewhere on the board
A7: U1101.1 (A7); also elsewhere on the board
GND: C1101.2, C1102.1, C1103.1, U1101.12 (GND), U1101.19 (A10), U1101.22 (A9), U1101.23 (A8), U1102.10 (GND), U1102.11 (2A3), U1102.13 (2A2), U1102.15 (2A1), U1102.17 (2A0), U1103.10 (GND); also elsewhere on the board
MD0: U1101.9 (D0), U1102.18 (1Y0), U1103.18 (1Y0); also elsewhere on the board
MD1: U1101.10 (D1), U1102.16 (1Y1), U1103.16 (1Y1); also elsewhere on the board
MD2: U1101.11 (D2), U1102.14 (1Y2), U1103.14 (1Y2); also elsewhere on the board
MD3: U1101.13 (D3), U1102.12 (1Y3), U1103.12 (1Y3); also elsewhere on the board
MD4: U1101.14 (D4), U1102.3 (2Y0), U1103.3 (2Y0); also elsewhere on the board
MD5: U1101.15 (D5), U1102.5 (2Y1), U1103.5 (2Y1); also elsewhere on the board
MD6: U1101.16 (D6), U1102.7 (2Y2), U1103.7 (2Y2); also elsewhere on the board
MD7: U1101.17 (D7), U1102.9 (2Y3), U1103.9 (2Y3); also elsewhere on the board
PC_Q0: U1103.2 (1A0); also elsewhere on the board
PC_Q1: U1103.4 (1A1); also elsewhere on the board
PC_Q2: U1103.6 (1A2); also elsewhere on the board
PC_Q3: U1103.8 (1A3); also elsewhere on the board
PC_Q4: U1103.17 (2A0); also elsewhere on the board
PC_Q5: U1103.15 (2A1); also elsewhere on the board
PC_Q6: U1103.13 (2A2); also elsewhere on the board
PC_Q7: U1103.11 (2A3); also elsewhere on the board
VDD: C1101.1, C1102.2, C1103.2, U1101.24 (VCC), U1102.20 (VCC), U1103.20 (VCC); also elsewhere on the board
YD0: U1102.2 (1A0); also elsewhere on the board
YD1: U1102.4 (1A1); also elsewhere on the board
YD2: U1102.6 (1A2); also elsewhere on the board
YD3: U1102.8 (1A3); also elsewhere on the board
~CS_RAM: U1101.18 (~CS); also elsewhere on the board
~OE_RAM: U1101.20 (~OE); also elsewhere on the board
~WE_RAM: U1101.21 (~W); also elsewhere on the board
~YEN_PC: U1103.1 (1OE), U1103.19 (2OE); also elsewhere on the board
~YEN_Y: U1102.1 (1OE), U1102.19 (2OE); also elsewhere on the board

Schematic: addrMUX.kicad_sch

Parts:
C1401, C1402, C1403, C1404, C1407, C1408, C1409: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U1401: 74HC138; DIP-16_W7.62mm_Socket
U1402, U1403, U1404, U1405: 74HC244; DIP-20_W7.62mm_Socket
U1406: 74HC157; DIP-16_W7.62mm_Socket
U1407: 74HC139; DIP-16_W7.62mm_Socket

Connections:
A0: U1402.18 (1Y0), U1403.18 (1Y0), U1404.18 (1Y0), U1405.18 (1Y0); also elsewhere on the board
A1: U1402.16 (1Y1), U1403.16 (1Y1), U1404.16 (1Y1), U1405.16 (1Y1); also elsewhere on the board
A2: U1402.14 (1Y2), U1403.14 (1Y2), U1404.14 (1Y2), U1405.14 (1Y2); also elsewhere on the board
A3: U1402.12 (1Y3), U1403.12 (1Y3), U1404.12 (1Y3), U1405.12 (1Y3); also elsewhere on the board
A4: U1402.3 (2Y0), U1403.3 (2Y0), U1404.3 (2Y0), U1405.3 (2Y0); also elsewhere on the board
A5: U1402.5 (2Y1), U1403.5 (2Y1), U1404.5 (2Y1), U1405.5 (2Y1); also elsewhere on the board
A6: U1402.7 (2Y2), U1403.7 (2Y2), U1404.7 (2Y2), U1405.7 (2Y2); also elsewhere on the board
A7: U1402.9 (2Y3), U1403.9 (2Y3), U1404.9 (2Y3), U1405.9 (2Y3); also elsewhere on the board
EXE: U1401.6 (E2), U1403.1 (1OE), U1403.19 (2OE); also elsewhere on the board
GND: C1401.2, C1402.2, C1403.2, C1404.2, C1407.2, C1408.2, C1409.2, U1401.3 (A2), U1401.4 (~E0), U1401.5 (~E1), U1401.8 (GND), U1402.10 (GND), U1403.10 (GND), U1404.8 (1A3), U1404.10 (GND), U1405.10 (GND), U1406.8 (GND), U1406.10 (I1c), U1406.11 (I0c), U1406.13 (I1d), U1406.14 (I0d), U1406.15 (E), U1407.8 (GND); also elsewhere on the board
INPUT0: U1407.4 (O0); also elsewhere on the board
INPUT1: U1407.5 (O1); also elsewhere on the board
INPUT2: U1407.6 (O2); also elsewhere on the board
INPUT3: U1407.7 (O3); also elsewhere on the board
OPR4: U1402.2 (1A0), U1406.2 (I0a); also elsewhere on the board
OPR5: U1402.4 (1A1), U1406.5 (I0b); also elsewhere on the board
OPR6: U1402.6 (1A2); also elsewhere on the board
OPR7: U1402.8 (1A3); also elsewhere on the board
OPR8: U1402.17 (2A0), U1406.3 (I1a); also elsewhere on the board
OPR9: U1402.15 (2A1), U1406.6 (I1b); also elsewhere on the board
OPR10: U1402.13 (2A2); also elsewhere on the board
OPR11: U1402.11 (2A3); also elsewhere on the board
OUTPUT0: U1407.12 (O0); also elsewhere on the board
OUTPUT1: U1407.11 (O1); also elsewhere on the board
OUTPUT2: U1407.10 (O2); also elsewhere on the board
OUTPUT3: U1407.9 (O3); also elsewhere on the board
PC_Q0: U1403.2 (1A0); also elsewhere on the board
PC_Q1: U1403.4 (1A1); also elsewhere on the board
PC_Q2: U1403.6 (1A2); also elsewhere on the board
PC_Q3: U1403.8 (1A3); also elsewhere on the board
PC_Q4: U1403.17 (2A0); also elsewhere on the board
PC_Q5: U1403.15 (2A1); also elsewhere on the board
PC_Q6: U1403.13 (2A2); also elsewhere on the board
PC_Q7: U1403.11 (2A3); also elsewhere on the board
SEL_IMM: U1406.1 (S); also elsewhere on the board
SEL_M0: U1401.1 (A0), U1405.6 (1A2); also elsewhere on the board
SEL_M1: U1401.2 (A1); also elsewhere on the board
SP0: U1404.2 (1A0); also elsewhere on the board
SP1: U1404.4 (1A1); also elsewhere on the board
SP2: U1404.6 (1A2); also elsewhere on the board
VDD: C1401.1, C1402.1, C1403.1, C1404.1, C1407.1, C1408.1, C1409.1, U1401.16 (VCC), U1402.20 (VCC), U1403.20 (VCC), U1404.11 (2A3), U1404.13 (2A2), U1404.15 (2A1), U1404.17 (2A0), U1404.20 (VCC), U1405.8 (1A3), U1405.11 (2A3), U1405.13 (2A2), U1405.15 (2A1), U1405.17 (2A0), U1405.20 (VCC), U1406.16 (VCC), U1407.16 (VCC); also elsewhere on the board
port0: U1405.2 (1A0), U1406.4 (Za), U1407.2 (A0), U1407.14 (A0)
port1: U1405.4 (1A1), U1406.7 (Zb), U1407.3 (A1), U1407.13 (A1)
~OE_iAddr: U1401.13 (~Y2), U1407.1 (E)
~OE_ioAddr: U1405.1 (1OE), U1405.19 (2OE); also elsewhere on the board
~OE_mAddr: U1401.15 (~Y0), U1402.1 (1OE), U1402.19 (2OE)
~OE_oAddr: U1401.12 (~Y3), U1407.15 (E)
~OE_spAddr: U1401.14 (~Y1), U1404.1 (1OE), U1404.19 (2OE)

Notes on the sheet:
mAddr

Schematic: Decoder.kicad_sch

Parts:
C701, C702, C703, C704, C705, C706: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
U701, U702, U705: 74HC273; DIP-20_W7.62mm_Socket
U703, U704, U706: 28C256; DIP-28_W15.24mm_Socket

Connections:
C_WE: U705.6 (Q2); also elsewhere on the board
DCR: U701.11 (Cp), U702.11 (Cp), U705.11 (Cp); also elsewhere on the board
GND: C701.1, C702.1, C703.1, C704.1, C705.1, C706.1, U701.10 (GND), U702.10 (GND), U703.1 (A14), U703.2 (A12), U703.14 (GND), U703.20 (~CS), U703.21 (A10), U703.22 (~OE), U703.23 (A11), U703.26 (A13), U704.1 (A14), U704.2 (A12), U704.14 (GND), U704.20 (~CS), U704.21 (A10), U704.22 (~OE), U704.23 (A11), U704.26 (A13), U705.10 (GND), U706.1 (A14), U706.2 (A12), U706.14 (GND), U706.20 (~CS), U706.21 (A10), U706.22 (~OE), U706.23 (A11), U706.26 (A13); also elsewhere on the board
unnamed: U701.3 (D0), U703.11 (D0)
unnamed: U701.4 (D1), U703.12 (D1)
unnamed: U701.7 (D2), U703.13 (D2)
unnamed: U701.8 (D3), U703.15 (D3)
unnamed: U701.13 (D4), U703.16 (D4)
unnamed: U701.14 (D5), U703.17 (D5)
unnamed: U701.17 (D6), U703.18 (D6)
unnamed: U701.18 (D7), U703.19 (D7)
unnamed: U702.3 (D0), U704.11 (D0)
unnamed: U702.4 (D1), U704.12 (D1)
unnamed: U702.7 (D2), U704.13 (D2)
unnamed: U702.8 (D3), U704.15 (D3)
unnamed: U702.13 (D4), U704.16 (D4)
unnamed: U702.14 (D5), U704.17 (D5)
unnamed: U702.17 (D6), U704.18 (D6)
unnamed: U702.18 (D7), U704.19 (D7)
unnamed: U705.3 (D0), U706.11 (D0)
unnamed: U705.4 (D1), U706.12 (D1)
unnamed: U705.7 (D2), U706.13 (D2)
unnamed: U705.8 (D3), U706.15 (D3)
unnamed: U705.13 (D4), U706.16 (D4)
unnamed: U705.14 (D5), U706.17 (D5)
unnamed: U705.17 (D6), U706.18 (D6)
unnamed: U705.18 (D7), U706.19 (D7)
OPC0: U703.6 (A4), U704.6 (A4), U706.6 (A4); also elsewhere on the board
OPC1: U703.5 (A5), U704.5 (A5), U706.5 (A5); also elsewhere on the board
OPC2: U703.4 (A6), U704.4 (A6), U706.4 (A6); also elsewhere on the board
OPC3: U703.3 (A7), U704.3 (A7), U706.3 (A7); also elsewhere on the board
OPR0: U703.10 (A0), U704.10 (A0), U706.10 (A0); also elsewhere on the board
OPR1: U703.9 (A1), U704.9 (A1), U706.9 (A1); also elsewhere on the board
OPR2: U703.8 (A2), U704.8 (A2), U706.8 (A2); also elsewhere on the board
OPR3: U703.7 (A3), U704.7 (A3), U706.7 (A3); also elsewhere on the board
PC_LOAD: U701.15 (Q5); also elsewhere on the board
RegAddrSrc: U701.12 (Q4); also elsewhere on the board
SEL_A: U702.12 (Q4); also elsewhere on the board
SEL_B0: U702.15 (Q5); also elsewhere on the board
SEL_B1: U702.16 (Q6); also elsewhere on the board
SEL_IMM: U702.19 (Q7); also elsewhere on the board
SEL_M0: U701.5 (Q1); also elsewhere on the board
SEL_M1: U701.6 (Q2); also elsewhere on the board
SEL_PC: U701.9 (Q3); also elsewhere on the board
SEL_Y: U701.2 (Q0); also elsewhere on the board
SP_CD: U701.19 (Q7); also elsewhere on the board
SP_CU: U701.16 (Q6); also elsewhere on the board
VDD: C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, U701.20 (VCC), U702.20 (VCC), U703.27 (~WE), U703.28 (VCC), U704.27 (~WE), U704.28 (VCC), U705.20 (VCC), U706.27 (~WE), U706.28 (VCC); also elsewhere on the board
WR: U705.12 (Q4); also elsewhere on the board
Z_WE: U705.9 (Q3); also elsewhere on the board
alu_code0: U702.2 (Q0); also elsewhere on the board
alu_code1: U702.5 (Q1); also elsewhere on the board
alu_code2: U702.6 (Q2); also elsewhere on the board
alu_code3: U702.9 (Q3); also elsewhere on the board
carry_in: U703.25 (A8), U704.25 (A8), U706.25 (A8); also elsewhere on the board
zero_prev: U703.24 (A9), U704.24 (A9), U706.24 (A9); also elsewhere on the board
~RST: U701.1 (~Mr), U702.1 (~Mr), U705.1 (~Mr); also elsewhere on the board
~SEL_Y: U705.15 (Q5); also elsewhere on the board
~WE: U705.2 (Q0); also elsewhere on the board
~WR: U705.5 (Q1); also elsewhere on the board

Notes on the sheet:
デコーダ

Board: 2 copper layers, 307 parts (0 on the bottom side), 377 nets, no tracks yet.

Other parts of the board:
D301, D302, D303, D304, D305, D306, D307, D308, D309, D310, D311, D312, D313, D314, D315, D316: LED; LED_D3.0mm_Clear
RN301, RN302: 4.7K; R_Array_SIP9

Their connections:
/RS01/I0a0: D316.2 (A); also elsewhere on the board
/RS01/I0a1: D308.2 (A); also elsewhere on the board
/RS01/I0a2: D315.2 (A); also elsewhere on the board
/RS01/I0a3: D307.2 (A); also elsewhere on the board
/RS01/I0b0: D314.2 (A); also elsewhere on the board
/RS01/I0b1: D306.2 (A); also elsewhere on the board
/RS01/I0b2: D313.2 (A); also elsewhere on the board
/RS01/I0b3: D305.2 (A); also elsewhere on the board
/RS01/I1a0: D312.2 (A); also elsewhere on the board
/RS01/I1a1: D304.2 (A); also elsewhere on the board
/RS01/I1a2: D311.2 (A); also elsewhere on the board
/RS01/I1a3: D303.2 (A); also elsewhere on the board
/RS01/I1b0: D310.2 (A); also elsewhere on the board
/RS01/I1b1: D302.2 (A); also elsewhere on the board
/RS01/I1b2: D309.2 (A); also elsewhere on the board
/RS01/I1b3: D301.2 (A); also elsewhere on the board
GND: RN301.1 (common), RN302.1 (common); also elsewhere on the board
unnamed: D301.1 (K), RN301.2 (R1)
unnamed: D302.1 (K), RN302.2 (R1)
unnamed: D303.1 (K), RN301.3 (R2)
unnamed: D304.1 (K), RN302.3 (R2)
unnamed: D305.1 (K), RN301.4 (R3)
unnamed: D306.1 (K), RN302.4 (R3)
unnamed: D307.1 (K), RN301.5 (R4)
unnamed: D308.1 (K), RN302.5 (R4)
unnamed: D309.1 (K), RN301.6 (R5)
unnamed: D310.1 (K), RN302.6 (R5)
unnamed: D311.1 (K), RN301.7 (R6)
unnamed: D312.1 (K), RN302.7 (R6)
unnamed: D313.1 (K), RN301.8 (R7)
unnamed: D314.1 (K), RN302.8 (R7)
unnamed: D315.1 (K), RN301.9 (R8)
unnamed: D316.1 (K), RN302.9 (R8)

## KiCad design peripherals/7segIF/hardware/7segIF.kicad_pcb

File peripherals/7segIF/README.md:

# 7segIF — TB-04 用 4bit→7セグメント表示ユニット

本回路は ちぇりーたくあん氏 の nlp リポジトリ（<https://github.com/cherry-takuan/nlp> 、`nlp-16a/Hardware/debug`、CC BY-SA 4.0）を一部参考にし、改変して作成しています。本ユニットのハードウェアも CC BY-SA 4.0 で公開します。

自作 4bit CPU **TB-04** の OUT ポート（4bit）に外付けし、`0`〜`F` を1桁の7セグメントLEDに表示する周辺ユニットです。本体改造は不要で、OUT ポート端子に接続するだけで動作します。ver1／ver2 どちらとも組み合わせられる**版非依存**ユニットのため、リポジトリ直下の `peripherals/` に置いています。

## 構成

| 項目 | 内容 |
|---|---|
| MCU | CH32V003F4P6（WCH・RISC-V, TSSOP-20） |
| 表示器 | OSL10564 シリーズ（コモンアノード・1桁。型番の末尾は発光色で変わる）。回路図・基板のシンボルとフットプリントは LTS-6960HR のものを使用 |
| 電源 | 5V 単一（TB-04 の 74HC 系と共通） |
| デコード方式 | MCU のルックアップテーブル（`0`〜`F` → セグメントパターン） |
| コネクタ | J2（TB-04 OUT 入力）／J1（WCH-Link ＋ UART 兼用ヘッダ） |

## 外観と回路図

基板は 23×41.5mm です。

## ディレクトリ

```
peripherals/7segIF/
  hardware/            回路図・基板（KiCAD, CC BY-SA 4.0）
  firmware/
    main.c             通常版（0〜F をリアルタイム表示）
    main_dp_blink.c    お遊び版（DP を 0.5 秒周期で点滅）
  LICENSE              CC BY-SA 4.0（ハードウェア設計に適用）
  README.md            このファイル
```

## 実配線

- 入力（TB-04 OUT → J2）: `D0=PC0  D1=PC1  D2=PC2  D3=PC3`（PORTC[3:0]）
- 出力（→ 7セグ, 各3.3K）: `a=PD0 b=PD1 c=PD2 d=PD3 e=PD4 f=PD5 g=PD6 DP=PD7`（PORTD[7:0]）
- コモンアノードのため、セグメントは MCU ピン LOW(0) で点灯。

## ファームのビルド・書き込み（MounRiver Studio ＋ WCH SPL）

1. CH32V003F4P6 の新規プロジェクトを作成し、生成される `User/main.c` を `firmware/main.c`（または `main_dp_blink.c`）の内容で**置き換える**。`main()` を持つファイルは1つだけにすること。
2. 初回書き込み時にコードプロテクトで弾かれる場合は、WCH-LinkUtility の `Target → Clear All Code Flash-Protect` で保護解除。接続リセットは **by power off**（本基板は NRST 線をヘッダに出していないため）。
3. **seg b（PD1）は既定で SDI（単線デバッグ）ピン**。ファーム側で SDI を無効化しないと seg b が点灯しません（本リポジトリのファームは対応済み：`GPIO_PinRemapConfig(GPIO_Remap_SDI_Disable, ENABLE)`）。SDI 無効化後はライブデバッグ不可、再書き込みは power-off unlock で行います。
4. **DP（PD7）は既定 NRST**。DP を光らせるにはオプションバイト `RST_MODE` を GPIO 側に設定します（数字 `a`〜`g` のみなら不要）。

## ライセンス

- **ハードウェア**（`hardware/`）: CC BY-SA 4.0。詳細・帰属は [`LICENSE`](./LICENSE) を参照。
- **ファームウェア**（`firmware/`）: ちぇりー氏の著作物に由来しない独自実装で、上記 CC BY-SA の対象外です。リポジトリ全体と同じ [MIT License](../../LICENSE) です。

Parts:
AFF1: LTS-6960HR; 7SegmentLED_LTS6760_LTS6780
C1: 100u; CP_Radial_D4.0mm_P2.00mm
C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_D3.0mm
J1: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
J2: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9: 3.3K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: CH32V003F4P6; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
GND: C1.2, C2.2, D1.1 (K), J1.6, J2.9, J2.10, U1.7 (VSS)
unnamed: AFF1.5 (DP), R8.2
unnamed: AFF1.7 (a), R1.2
unnamed: AFF1.6 (b), R2.2
unnamed: AFF1.4 (c), R7.2
unnamed: AFF1.2 (d), R6.2
unnamed: AFF1.1 (e), R5.2
unnamed: AFF1.9 (f), R4.2
unnamed: AFF1.10 (g), R3.2
unnamed: D1.2 (A), R9.2
unnamed: J2.2, U1.13 (PC3)
unnamed: J2.4, U1.12 (PC2)
unnamed: J2.6, U1.11 (PC1)
unnamed: J2.8, U1.10 (PC0)
unnamed: R1.1, U1.8 (PD0)
unnamed: R7.1, U1.19 (PD2)
unnamed: R6.1, U1.20 (PD3)
unnamed: R5.1, U1.1 (PD4)
unnamed: R8.1, U1.4 (PD7)
RX: J1.3, R3.1, U1.3 (PD6)
SWDIO: J1.4, R2.1, U1.18 (PD1)
TX: J1.1, R4.1, U1.2 (PD5)
VDD: AFF1.3 (C.A.), AFF1.8 (C.A.), C1.1, C2.1, J1.10, J2.1, R9.1, U1.9 (VDD)

Notes on the sheet:
もとの回路図との違い ・J1を左右逆にした
WCH-Link E
SWCLK SWDIO GND 3V3 5V
RX TX GND 3V3 5V

Board: 2 copper layers, 23.0 x 41.5 mm, 16 parts (0 on the bottom side), 23 nets.

## KiCad design ver1/hardware/4bit-addr/TB04addr4bitVer3.kicad_pcb

File ver1/hardware/README.md:

# TB-04 ver1 ハードウェア

自作4bitCPU **TB-04** の ver1（アドレス4bit版・2026-06 完成）の KiCAD プロジェクトです。
仕様・命令セット・使い方は [`ver1/README.md`](../README.md) を参照してください。

| 項目 | 仕様 |
|------|------|
| データ幅 | 4bit |
| アドレス幅 | 4bit（16語） |
| 汎用レジスタ | R0〜R3 |
| フラグ | C（キャリー）、Z（ゼロ） |
| ALU | ROM実装（4bitコード・9演算） |
| デコーダ | ROM実装（28C256 × 2 並列） |
| プログラムROM | 28C256（ZIFソケット） |
| 制御タイミング | 4フェーズ（WB → FCH → DCR → EXE、WB 始まり）・1命令＝4クロック |

回路図の PDF: [`4bit-addr/TB04addr4bitVer3.pdf`](4bit-addr/TB04addr4bitVer3.pdf)

## 回路図・PCB と実機の関係

- 実機は、最初に製作した PCB に**立体配線で改造**を加えたものです（2026-06-15、ジャンプのディレイスロットをなくすためにフェーズ構成を変更）。
- **回路図はこの改造を反映済み**です（2026-06-30・08-10 に修正）。
- **PCB ファイル（`TB04addr4bitVer3.kicad_pcb`）は改造の反映が途中**で、未配線や短絡が残っています。このままでは製造に使えません。

アドレスを 8bit に広げた後継は [`ver2/`](../../ver2/) です。

## ライブラリの登録

このリポジトリにはカスタムシンボル・フットプリントが含まれています。
回路図・PCBを正しく開くには、KiCADのライブラリパスに以下を登録してください。

### シンボルライブラリ

`環境設定 → シンボルライブラリを管理` で以下を追加:

| ライブラリ名 | ファイル |
|---|---|
| `New_Library` | `symbols/New_Library.kicad_sym` |
| `originalCPU` | `symbols/originalCPU.kicad_sym` |
| `74HC161` | `symbols/74HC161N.kicad_sym` |

### フットプリントライブラリ

`環境設定 → フットプリントライブラリを管理` で以下を追加:

| ライブラリ名 | フォルダ |
|---|---|
| `Library` | `footprints/Library.pretty` |

## KiCADプロジェクト構成

| シート | 内容 |
|--------|------|
| TB04addr4bitVer3.kicad_sch | トップシート（電源・WEデコード） |
| RS.kicad_sch | レジスタ群①：汎用レジスタ R0〜R3（74HC161 × 4 ＋ 74HC253 × 4） |
| RS01.kicad_sch | レジスタ群②：PC・入出力ポート・OPR から ALU への出力（即値） |
| ROM_ALU_Decoder.kicad_sch | ROM（28C256 × 4）・位相カウンタ（74HC161 でクロックを数えフェーズ信号を作る）・フラグ |
| ALU.kicad_sch | LEDモニターインターフェース |
| clk_rst.kicad_sch | クロック・リセット |
| TB04addr4bitVer3.kicad_pcb | PCBレイアウト |

Board: 2 copper layers, 220.0 x 180.0 mm, 176 parts (0 on the bottom side), 217 nets.

Parts:
C1, C2, C3, C4, C5, C6, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C34, C35, C36: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C7: 100u; CP_Radial_D5.0mm_P2.00mm
C32, C33: 10u 16V; CP_Radial_D5.0mm_P2.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53: LED; LED_D3.0mm_Clear
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
IC1, IC2, IC3, IC4, IC5, IC6, IC7, IC8, IC9: 74HC161N; DIP-16_W7.62mm_Socket
J1: USB_C_Receptacle_PowerOnly_6P; USB_C_receptacle_onlypower_tanuki
J2: Conn_01x06_Socket; PinSocket_1x06_P2.54mm_Vertical
J3: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
R1, R30, R31: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R4, R5, R8, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R7: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R21, R22, R28, R29: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R23: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R24, R25: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R26, R27: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1, RN2, RN7, RN9: 4.7K; R_Array_SIP9
RN3, RN5, RN6, RN8: 4.7K; R_Array_SIP5
RN4: 10K; R_Array_SIP5
SW1, SW5: SW_SPDT; sw_slide
SW2, SW3, SW4: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
SW6, SW7: SW_Push; SW_Tactile_Straight_KSL0Axx1LFTR
U1, U2, U3, U4, U6, U7, U8, U9: 74LS253; DIP-16_W7.62mm_Socket
U5, U22, U23: 28C256; DIP-28_W15.24mm_Socket
U10: OSC8MI/H; Oscillator_DIP-8
U11, U18, U19: 74LS273; DIP-20_W7.62mm_Socket
U12, U13: 4040; DIP-16_W7.62mm_Socket
U14: 74HC238; DIP-16_W7.62mm_Socket
U15: 74HC138; DIP-16_W7.62mm_Socket
U16: 74HC00; DIP-14_W7.62mm_Socket
U17: 74HC14; DIP-14_W7.62mm_Socket
U20: 74HC273; DIP-20_W7.62mm_Socket
U21: 74HC74; DIP-14_W7.62mm_Socket
U24: 28C256; DIP_Socket-28_W11.9mm_W12.7mm_W15.24mm_W17.78mm_W18.5mm_3M_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

Connections:
/RS00/I0a0: D4.2 (A), IC1.14 (Q0), U1.6 (I0a), U3.6 (I0a)
/RS00/I0a1: D8.2 (A), IC2.14 (Q0), U1.5 (I1a), U3.5 (I1a)
/RS00/I0a2: D12.2 (A), IC3.14 (Q0), U1.4 (I2a), U3.4 (I2a)
/RS00/I0a3: D16.2 (A), IC4.14 (Q0), U1.3 (I3a), U3.3 (I3a)
/RS00/I0b0: D3.2 (A), IC1.13 (Q1), U1.10 (I0b), U3.10 (I0b)
/RS00/I0b1: D7.2 (A), IC2.13 (Q1), U1.11 (I1b), U3.11 (I1b)
/RS00/I0b2: D11.2 (A), IC3.13 (Q1), U1.12 (I2b), U3.12 (I2b)
/RS00/I0b3: D15.2 (A), IC4.13 (Q1), U1.13 (I3b), U3.13 (I3b)
/RS00/I1a0: D2.2 (A), IC1.12 (Q2), U2.6 (I0a), U4.6 (I0a)
/RS00/I1a1: D6.2 (A), IC2.12 (Q2), U2.5 (I1a), U4.5 (I1a)
/RS00/I1a2: D10.2 (A), IC3.12 (Q2), U2.4 (I2a), U4.4 (I2a)
/RS00/I1a3: D14.2 (A), IC4.12 (Q2), U2.3 (I3a), U4.3 (I3a)
/RS00/I1b0: D1.2 (A), IC1.11 (Q3), U2.10 (I0b), U4.10 (I0b)
/RS00/I1b1: D5.2 (A), IC2.11 (Q3), U2.11 (I1b), U4.11 (I1b)
/RS00/I1b2: D9.2 (A), IC3.11 (Q3), U2.12 (I2b), U4.12 (I2b)
/RS00/I1b3: D13.2 (A), IC4.11 (Q3), U2.13 (I3b), U4.13 (I3b)
/RS00/OUT0a: R12.1, U1.7 (Za)
/RS00/OUT0b: R10.1, U3.7 (Za)
/RS00/OUT1a: R5.1, U1.9 (Zb)
/RS00/OUT1b: R3.1, U3.9 (Zb)
/RS00/OUT2a: R11.1, U2.7 (Za)
/RS00/OUT2b: R8.1, U4.7 (Za)
/RS00/OUT3a: R4.1, U2.9 (Zb)
/RS00/OUT3b: R2.1, U4.9 (Zb)
/RS01/I1a0: IC5.12 (Q2), U7.6 (I0a), U9.6 (I0a)
/RS01/I1b0: IC5.11 (Q3), U7.10 (I0b), U9.10 (I0b)
/RS01/OUT0a: R20.1, U6.7 (Za)
/RS01/OUT0b: R18.1, U8.7 (Za)
/RS01/OUT1a: R16.1, U6.9 (Zb)
/RS01/OUT1b: R14.1, U8.9 (Zb)
/RS01/OUT2a: R19.1, U7.7 (Za)
/RS01/OUT2b: R17.1, U9.7 (Za)
/RS01/OUT3a: R15.1, U7.9 (Zb)
/RS01/OUT3b: R13.1, U9.9 (Zb)
/RS01/~Ena: U6.1 (OEa), U6.15 (OEb), U7.1 (OEa), U7.15 (OEb), U16.3
/RS01/~Enb: U8.1 (OEa), U8.15 (OEb), U9.1 (OEa), U9.15 (OEb), U16.6
A0: D53.2 (A), IC7.14 (Q0), U24.10 (A0)
A1: D52.2 (A), IC7.13 (Q1), U24.9 (A1)
A2: D51.2 (A), IC7.12 (Q2), U24.8 (A2)
A3: D50.2 (A), IC7.11 (Q3), U24.7 (A3)
A4: D47.2 (A), IC6.14 (Q0)
A5: D46.2 (A), IC6.13 (Q1)
A6: D45.2 (A), IC6.12 (Q2)
A7: D44.2 (A), IC6.11 (Q3)
CLK_CPU: IC1.2 (CP), IC2.2 (CP), IC3.2 (CP), IC4.2 (CP), IC5.2 (CP), IC6.2 (CP), IC7.2 (CP), IC8.2 (CP), IC9.2 (CP), J3.5, U17.8
CNTABL: IC6.7 (CEP), IC7.7 (CEP), IC7.10 (CET), U16.11
DI0: IC1.3 (D0), IC2.3 (D0), IC3.3 (D0), IC4.3 (D0), IC5.3 (D0), IC6.3 (D0), IC7.3 (D0), IC8.3 (D0), U11.2 (Q0)
DI1: IC1.4 (D1), IC2.4 (D1), IC3.4 (D1), IC4.4 (D1), IC5.4 (D1), IC6.4 (D1), IC7.4 (D1), IC8.4 (D1), U11.5 (Q1)
DI2: IC1.5 (D2), IC2.5 (D2), IC3.5 (D2), IC4.5 (D2), IC5.5 (D2), IC6.5 (D2), IC7.5 (D2), IC8.5 (D2), U11.6 (Q2)
DI3: IC1.6 (D3), IC2.6 (D3), IC3.6 (D3), IC4.6 (D3), IC5.6 (D3), IC6.6 (D3), IC7.6 (D3), IC8.6 (D3), U11.9 (Q3)
DOa0: R12.2, R20.2, U5.10 (A0)
DOa1: R5.2, R16.2, U5.9 (A1)
DOa2: R11.2, R19.2, U5.8 (A2)
DOa3: R4.2, R15.2, U5.7 (A3)
DOb0: R10.2, R18.2, U5.6 (A4)
DOb1: R3.2, R14.2, U5.5 (A5)
DOb2: R8.2, R17.2, U5.4 (A6)
DOb3: R2.2, R13.2, U5.3 (A7)
Decord: D40.2 (A), U14.13 (Y2), U16.9, U18.11 (Cp), U19.11 (Cp)
Execute: D39.2 (A), U11.11 (Cp), U14.12 (Y3), U15.6 (E2), U21.3 (C), U21.11 (C)
Fetch: D41.2 (A), U14.14 (Y1), U20.11 (Cp)
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.1, C30.1, C31.1, C32.2, C33.2, C34.1, C35.1, C36.1, D21.1 (K), D42.1 (K), D43.1 (K), D48.1 (K), D49.1 (K), H1.1, H2.1, H3.1, H4.1, IC1.7 (CEP), IC1.8 (GND), IC1.10 (CET), IC2.7 (CEP), IC2.8 (GND), IC2.10 (CET), IC3.7 (CEP), IC3.8 (GND), IC3.10 (CET), IC4.7 (CEP), IC4.8 (GND), IC4.10 (CET), IC5.7 (CEP), IC5.8 (GND), IC5.10 (CET), IC6.8 (GND), IC7.8 (GND), IC8.7 (CEP), IC8.8 (GND), IC8.10 (CET), IC9.3 (D0), IC9.4 (D1), IC9.5 (D2), IC9.6 (D3), IC9.8 (GND), IC9.9 (~PE), J1.1 (B_12_GND), J1.6 (A12_GND), J2.6, J3.9, J3.10, R1.2, R6.1, R7.1, RN1.1 (common), RN2.1 (common), RN3.1 (common), RN4.1 (common), RN5.1 (common), RN6.1 (common), RN7.1 (common), RN8.1 (common), RN9.1 (common), SW6.1, SW7.1, U1.8 (GND), U2.8 (GND), U3.8 (GND), U4.8 (GND), U5.1 (A14), U5.2 (A12), U5.14 (GND), U5.20 (~CS), U5.22 (~OE), U5.26 (A13), U6.5 (I1a), U6.8 (GND), U6.11 (I1b), U7.5 (I1a), U7.8 (GND), U7.11 (I1b), U8.3 (I3a), U8.4 (I2a), U8.5 (I1a), U8.8 (GND), U8.11 (I1b), U8.12 (I2b), U8.13 (I3b), U9.3 (I3a), U9.4 (I2a), U9.5 (I1a), U9.8 (GND), U9.11 (I1b), U9.12 (I2b), U9.13 (I3b), U10.4 (GND), U11.10 (GND), U11.13 (D4), U11.14 (D5), U11.17 (D6), U11.18 (D7), U12.8 (VSS), U13.8 (VSS), U14.3 (A2), U14.4 (~E1), U14.5 (~E2), U14.8 (GND), U15.5 (~E1), U15.8 (GND), U16.7 (GND), U17.7 (GND), U17.11, U17.13, U18.10 (GND), U19.10 (GND), U20.10 (GND), U21.7 (GND), U22.1 (A14), U22.2 (A12), U22.14 (GND), U22.20 (~CS), U22.21 (A10), U22.22 (~OE), U22.23 (A11), U22.26 (A13), U23.1 (A14), U23.2 (A12), U23.14 (GND), U23.20 (~CS), U23.21 (A10), U23.22 (~OE), U23.23 (A11), U23.26 (A13), U24.1 (A14), U24.2 (A12), U24.3 (A7), U24.4 (A6), U24.5 (A5), U24.6 (A4), U24.14 (GND), U24.20 (~CS), U24.21 (A10), U24.22 (~OE), U24.23 (A11), U24.24 (A9), U24.25 (A8), U24.26 (A13)
NOT_JMP: U16.10, U19.16 (Q6)
unnamed: C32.1, R24.1, R26.2
unnamed: C33.1, R25.1, R27.2
unnamed: D1.1 (K), RN1.2 (R1)
unnamed: D2.1 (K), RN1.3 (R2)
unnamed: D3.1 (K), RN1.4 (R3)
unnamed: D4.1 (K), RN1.5 (R4)
unnamed: D5.1 (K), RN1.6 (R5)
unnamed: D6.1 (K), RN1.7 (R6)
unnamed: D7.1 (K), RN1.8 (R7)
unnamed: D8.1 (K), RN1.9 (R8)
unnamed: D9.1 (K), RN2.2 (R1)
unnamed: D10.1 (K), RN2.3 (R2)
unnamed: D11.1 (K), RN2.4 (R3)
unnamed: D12.1 (K), RN2.5 (R4)
unnamed: D13.1 (K), RN2.6 (R5)
unnamed: D14.1 (K), RN2.7 (R6)
unnamed: D15.1 (K), RN2.8 (R7)
unnamed: D16.1 (K), RN2.9 (R8)
unnamed: D17.1 (K), RN3.2 (R1)
unnamed: D18.1 (K), RN3.3 (R2)
unnamed: D19.1 (K), RN3.4 (R3)
unnamed: D20.1 (K), RN3.5 (R4)
unnamed: D21.2 (A), R9.2
unnamed: D22.2 (A), J2.1, RN4.2 (R1), SW2.1, U7.13 (I3b)
unnamed: D22.1 (K), RN5.2 (R1)
unnamed: D23.2 (A), J2.2, RN4.3 (R2), SW2.2, U7.3 (I3a)
unnamed: D23.1 (K), RN5.3 (R2)
unnamed: D24.2 (A), J2.3, RN4.4 (R3), SW2.3, U6.13 (I3b)
unnamed: D24.1 (K), RN5.4 (R3)
unnamed: D25.2 (A), J2.4, RN4.5 (R4), SW2.4, U6.3 (I3a)
unnamed: D25.1 (K), RN5.5 (R4)
unnamed: D26.2 (A), IC8.11 (Q3), J3.2
unnamed: D26.1 (K), RN6.2 (R1)
unnamed: D27.2 (A), IC8.12 (Q2), J3.4
unnamed: D27.1 (K), RN6.3 (R2)
unnamed: D28.2 (A), IC8.13 (Q1), J3.6
unnamed: D28.1 (K), RN6.4 (R3)
unnamed: D29.2 (A), IC8.14 (Q0), J3.8
unnamed: D29.1 (K), RN6.5 (R4)
unnamed: D30.1 (K), RN7.2 (R1)
unnamed: D31.1 (K), RN7.3 (R2)
unnamed: D32.1 (K), RN7.4 (R3)
unnamed: D33.1 (K), RN7.5 (R4)
unnamed: D34.1 (K), RN7.6 (R5)
unnamed: D35.1 (K), RN7.7 (R6)
unnamed: D36.1 (K), RN7.8 (R7)
unnamed: D37.1 (K), RN7.9 (R8)
unnamed: D38.1 (K), RN8.5 (R4)
unnamed: D39.1 (K), RN8.2 (R1)
unnamed: D40.1 (K), RN8.3 (R2)
unnamed: D41.1 (K), RN8.4 (R3)
unnamed: D42.2 (A), R21.2
unnamed: D43.2 (A), R22.2
unnamed: D44.1 (K), RN9.2 (R1)
unnamed: D45.1 (K), RN9.3 (R2)
unnamed: D46.1 (K), RN9.4 (R3)
unnamed: D47.1 (K), RN9.5 (R4)
unnamed: D48.2 (A), R28.2
unnamed: D49.2 (A), R29.2
unnamed: D50.1 (K), RN9.6 (R5)
unnamed: D51.1 (K), RN9.7 (R6)
unnamed: D52.1 (K), RN9.8 (R7)
unnamed: D53.1 (K), RN9.9 (R8)
unnamed: IC5.14 (Q0), U6.6 (I0a), U8.6 (I0a)
unnamed: IC5.13 (Q1), U6.10 (I0b), U8.10 (I0b)
unnamed: IC6.10 (CET), IC7.15 (TC)
unnamed: IC9.14 (Q0), U14.1 (A0)
unnamed: IC9.13 (Q1), U14.2 (A1)
unnamed: J1.3 (A5_CC1), R7.2
unnamed: J1.2 (B9_VBUS), J1.5 (A9_VBUS), SW1.2 (B)
unnamed: J1.4 (B5_CC2), R6.2
unnamed: R23.1, U17.6
unnamed: R24.2, U17.5
unnamed: R25.2, U17.1
unnamed: R26.1, R30.2, SW6.2
unnamed: R27.1, R31.2, SW7.2
unnamed: R23.2, SW5.1 (A)
unnamed: R28.1, SW5.2 (B), U17.9
unnamed: SW4.5, SW4.6, SW4.7, SW4.8, SW5.3 (C)
unnamed: SW3.1, U10.5 (Output), U12.10 (CLK)
unnamed: U5.11 (D0), U11.3 (D0)
unnamed: U5.12 (D1), U11.4 (D1)
unnamed: U5.13 (D2), U11.7 (D2)
unnamed: U5.15 (D3), U11.8 (D3)
unnamed: SW3.2, U12.9 (Q0)
unnamed: SW3.3, U12.6 (Q2)
unnamed: SW3.4, U12.15 (Q10)
unnamed: SW3.5, SW3.6, SW3.7, SW3.8, SW4.1, U13.10 (CLK)
unnamed: SW4.2, U13.7 (Q1)
unnamed: SW4.3, U13.12 (Q8)
unnamed: SW4.4, U13.1 (Q11)
unnamed: U16.8, U16.12, U16.13
unnamed: U18.3 (D0), U22.11 (D0)
unnamed: U18.4 (D1), U22.12 (D1)
unnamed: U18.7 (D2), U22.13 (D2)
unnamed: U18.8 (D3), U22.15 (D3)
unnamed: U18.13 (D4), U22.16 (D4)
unnamed: U18.14 (D5), U22.17 (D5)
unnamed: U18.17 (D6), U22.18 (D6)
unnamed: U18.18 (D7), U22.19 (D7)
unnamed: U19.3 (D0), U23.11 (D0)
unnamed: U19.4 (D1), U23.12 (D1)
unnamed: U19.7 (D2), U23.13 (D2)
unnamed: U19.8 (D3), U23.15 (D3)
unnamed: U19.13 (D4), U23.16 (D4)
unnamed: U19.14 (D5), U23.17 (D5)
unnamed: U19.17 (D6), U23.18 (D6)
unnamed: U19.18 (D7), U23.19 (D7)
unnamed: U20.3 (D0), U24.11 (D0)
unnamed: U20.4 (D1), U24.12 (D1)
unnamed: U20.7 (D2), U24.13 (D2)
unnamed: U20.8 (D3), U24.15 (D3)
unnamed: U20.13 (D4), U24.16 (D4)
unnamed: U20.14 (D5), U24.17 (D5)
unnamed: U20.17 (D6), U24.18 (D6)
unnamed: U20.18 (D7), U24.19 (D7)
OPC0: D33.2 (A), U20.2 (Q0), U22.10 (A0), U23.10 (A0)
OPC1: D32.2 (A), U20.5 (Q1), U22.9 (A1), U23.9 (A1)
OPC2: D31.2 (A), U20.6 (Q2), U22.8 (A2), U23.8 (A2)
OPC3: D30.2 (A), U20.9 (Q3), U22.7 (A3), U23.7 (A3)
OPR0: D37.2 (A), U6.4 (I2a), U20.12 (Q4), U22.6 (A4), U23.6 (A4)
OPR1: D36.2 (A), U6.12 (I2b), U20.15 (Q5), U22.5 (A5), U23.5 (A5)
OPR2: D35.2 (A), U7.4 (I2a), U20.16 (Q6), U22.4 (A6), U23.4 (A6)
OPR3: D34.2 (A), U7.12 (I2b), U20.19 (Q7), U22.3 (A7), U23.3 (A7)
RST: R29.1, U12.11 (Reset), U13.11 (Reset), U17.2, U17.3
Reg_RD_SEL0a: U1.14 (A0), U2.14 (A0), U6.14 (A0), U7.14 (A0), U18.9 (Q3)
Reg_RD_SEL0b: U3.14 (A0), U4.14 (A0), U8.14 (A0), U9.14 (A0), U18.16 (Q6)
Reg_RD_SEL1a: U1.2 (A1), U2.2 (A1), U6.2 (A1), U7.2 (A1), U18.12 (Q4)
Reg_RD_SEL1b: U3.2 (A1), U4.2 (A1), U8.2 (A1), U9.2 (A1), U18.19 (Q7)
Reg_RD_SEL2a: U1.1 (OEa), U1.15 (OEb), U2.1 (OEa), U2.15 (OEb), U16.1, U16.2, U18.15 (Q5)
Reg_RD_SEL2b: U3.1 (OEa), U3.15 (OEb), U4.1 (OEa), U4.15 (OEb), U16.4, U16.5, U19.2 (Q0)
Reg_WE_SEL0: U15.1 (A0), U18.2 (Q0)
Reg_WE_SEL1: U15.2 (A1), U18.5 (Q1)
Reg_WE_SEL2: U15.3 (A2), U18.6 (Q2)
VDD: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.2, C30.2, C31.2, C34.2, C35.2, C36.2, IC1.16 (VCC), IC2.16 (VCC), IC3.16 (VCC), IC4.16 (VCC), IC5.16 (VCC), IC6.16 (VCC), IC7.16 (VCC), IC8.16 (VCC), IC9.7 (CEP), IC9.10 (CET), IC9.16 (VCC), J2.5, J3.1, R1.1, R9.1, R30.1, R31.1, SW1.3 (C), SW2.5, SW2.6, SW2.7, SW2.8, U1.16 (VCC), U2.16 (VCC), U3.16 (VCC), U4.16 (VCC), U5.27 (~WE), U5.28 (VCC), U6.16 (VCC), U7.16 (VCC), U8.16 (VCC), U9.16 (VCC), U10.8 (VDD), U11.20 (VCC), U12.16 (VDD), U13.16 (VDD), U14.6 (E3), U14.16 (VCC), U15.16 (VCC), U16.14 (VCC), U17.14 (VCC), U18.20 (VCC), U19.20 (VCC), U20.20 (VCC), U21.1 (~R), U21.4 (~S), U21.10 (~S), U21.13 (~R), U21.14 (VCC), U22.27 (~WE), U22.28 (VCC), U23.27 (~WE), U23.28 (VCC), U24.27 (~WE), U24.28 (VCC)
WB: D38.2 (A), U14.15 (Y0)
alu_code0: D20.2 (A), U5.25 (A8), U19.5 (Q1)
alu_code1: D19.2 (A), U5.24 (A9), U19.6 (Q2)
alu_code2: D18.2 (A), U5.21 (A10), U19.9 (Q3)
alu_code3: D17.2 (A), U5.23 (A11), U19.12 (Q4)
carry_in: R22.1, U21.5 (Q), U22.25 (A8), U23.25 (A8)
carry_out: U5.16 (D4), U21.2 (D)
zero_flag: U5.17 (D5), U21.12 (D)
zero_prev: R21.1, U21.9 (Q), U22.24 (A9), U23.24 (A9)
~RST: IC1.1 (~MR), IC2.1 (~MR), IC3.1 (~MR), IC4.1 (~MR), IC5.1 (~MR), IC6.1 (~MR), IC7.1 (~MR), IC8.1 (~MR), IC9.1 (~MR), J3.3, U11.1 (~Mr), U17.4, U18.1 (~Mr), U19.1 (~Mr), U20.1 (~Mr)
~Reg_WE0: IC1.9 (~PE), U15.15 (~Y0)
~Reg_WE1: IC2.9 (~PE), U15.14 (~Y1)
~Reg_WE2: IC3.9 (~PE), U15.13 (~Y2)
~Reg_WE3: IC4.9 (~PE), U15.12 (~Y3)
~Reg_WE4: IC5.9 (~PE), U15.11 (~Y4)
~Reg_WE5: IC6.9 (~PE), U15.10 (~Y5)
~Reg_WE6: IC7.9 (~PE), U15.9 (~Y6)
~Reg_WE7: IC8.9 (~PE), U15.7 (~Y7)
~WE: U15.4 (~E0), U19.15 (Q5)

## Code that names these connections

File peripherals/7segIF/firmware/main.c:

/*
 * 7segIF firmware  ―  TB-04 の 4bit OUT を 0..F の7セグ表示にデコード
 *
 * MCU        : CH32V003F4P6 (RISC-V, QingKe V2A)
 * Toolchain  : MounRiver Studio ＋ WCH 標準ペリフェラルライブラリ(SPL)
 * Display    : LTS-6960HR（コモンアノード・赤）
 *
 * 実配線（2026-07-20 ネットリストで確定）:
 *   入力  TB-04 OUT → J1:  D0=PC0  D1=PC1  D2=PC2  D3=PC3   … PORTC[3:0]
 *   出力  → 7セグ(各3.3K):  a=PD0 b=PD1 c=PD2 d=PD3 e=PD4 f=PD5 g=PD6 DP=PD7 … PORTD[7:0]
 *   コモンアノード → セグメントは MCU ピン LOW(0) で点灯。
 *
 * 注意（回路は問題なし・ソフト/書込側の制約）:
 *   - PD1(seg b) は SWIO。GPIO 使用中はライブデバッグ不可。再書込は
 *     WCH-Link のパワーサイクル or ダウンローダの「ByPass/解除」で対応。
 *   - PD7(seg DP) は既定 NRST。オプションバイト RST_MODE を GPIO 側に
 *     設定するまで DP は光らない。数字 0..F(a..g) は設定なしでも動作する。
 *     MounRiver では書込時のダウンロード設定 or WCHISPTool で RST_MODE を変更する。
 *
 * MounRiver での使い方:
 *   1. 新規に CH32V003F4P6 のプロジェクトを作成。
 *   2. 生成される User/main.c を本ファイルで置き換える。
 *   3. Peripheral(SPL) の GPIO/RCC が有効なテンプレートであること（既定で可）。
 */

#include "debug.h"   /* ch32v00x.h / GPIO / RCC などを取り込む標準テンプレートヘッダ */
#include <stdint.h>

/*
 * セグメントパターン。bit0=a, bit1=b, ... bit6=g, bit7=DP。
 * 「1 = 点灯」で定義（コモンカソード表記）。
 * 実出力はコモンアノードなので main で反転し 0=点灯 にする。DP(bit7) は常に消灯。
 */
static const uint8_t SEG_ON[16] = {
    0x3F, /* 0 : a b c d e f   */
    0x06, /* 1 : b c           */
    0x5B, /* 2 : a b d e g     */
    0x4F, /* 3 : a b c d g     */
    0x66, /* 4 : b c f g       */
    0x6D, /* 5 : a c d f g     */
    0x7D, /* 6 : a c d e f g   */
    0x07, /* 7 : a b c         */
    0x7F, /* 8 : a b c d e f g */
    0x6F, /* 9 : a b c d f g   */
    0x77, /* A : a b c e f g   */
    0x7C, /* b : c d e f g     */
    0x39, /* C : a d e f       */
    0x5E, /* d : b c d e g     */
    0x79, /* E : a d e f g     */
    0x71, /* F : a e f g       */
};

int main(void)
{
    GPIO_InitTypeDef GPIO_InitStructure = {0};

    SystemCoreClockUpdate();

    /* GPIO ポート C / D ＋ AFIO のクロック供給 */
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOC | RCC_APB2Periph_GPIOD
                         | RCC_APB2Periph_AFIO, ENABLE);

    /*
     * PD1(seg b) は既定で SDI(単線デバッグ)。SDI を無効化して PD1 を GPIO に開放する。
     *   これをしないと GPIO_Init しても SDI がピンを握り続け、PD1 は駆動されない
     *   （seg b が常に消灯・PD1 が H 固定になる）。
     * 代償：以後ライブデバッグ不可。再書込は WCH-Link の power-off unlock、
     *   または PD1 を GND に落として電源投入し SWIO に戻してから行う。
     */
    GPIO_PinRemapConfig(GPIO_Remap_SDI_Disable, ENABLE);

    /*
     * PORTC PC0..PC3 = 入力フローティング
     *   TB-04 の 74HC 出力（プッシュプル・5V）が常にドライブするので pull 不要。
     *   断線時にブランク固定したいなら GPIO_Mode_IPD（内部プルダウン）に変更。
     */
    GPIO_InitStructure.GPIO_Pin   = GPIO_Pin_0 | GPIO_Pin_1 | GPIO_Pin_2 | GPIO_Pin_3;
    GPIO_InitStructure.GPIO_Mode  = GPIO_Mode_IN_FLOATING;
    GPIO_InitStructure.GPIO_Speed = GPIO_Speed_10MHz;
    GPIO_Init(GPIOC, &GPIO_InitStructure);

    /*
     * PORTD PD0..PD7 = 出力プッシュプル 10MHz
     *   off 状態は High 出力＝アノードもカソードも VDD 付近で消灯。
     */
    GPIO_InitStructure.GPIO_Pin   = GPIO_Pin_0 | GPIO_Pin_1 | GPIO_Pin_2 | GPIO_Pin_3
                                  | GPIO_Pin_4 | GPIO_Pin_5 | GPIO_Pin_6 | GPIO_Pin_7;
    GPIO_InitStructure.GPIO_Mode  = GPIO_Mode_Out_PP;
    GPIO_InitStructure.GPIO_Speed = GPIO_Speed_10MHz;
    GPIO_Init(GPIOD, &GPIO_InitStructure);

    /* 起動時は全消灯（コモンアノード＝全 High） */
    GPIO_Write(GPIOD, 0x00FF);

    while (1)
    {
        uint8_t v = (uint8_t)(GPIO_ReadInputData(GPIOC) & 0x0F);  /* D0..D3 → 0..15 */
        GPIO_Write(GPIOD, (uint16_t)(uint8_t)~SEG_ON[v]);         /* 0=点灯 に反転出力 */
    }
}

File ver2/pico_codes/forLogiAna.py:

# TB-04 ver2 用 Pico 高速ロジアナ（送信側）。PC側は同じディレクトリの logicAnalyzer.py
from machine import Pin, UART
import machine
import rp2

# PIOで125MHz(8ns)サンプリング。トリガー後の64サンプル(512ns)を取り込んでUARTへ送る
# トリガー＝ CH2(~CS_RAM)=L のあいだに CH0(CLK_CPU) が L→H（＝RAMを触る命令のEXE末）
# 入力は分圧抵抗（1kΩ + 2kΩ）経由。RC で 10ns 程度なまる点に注意

uart = UART(0, baudrate=115200, tx=Pin(0), rx=Pin(1))

NCH = 4                      # 4 か 8（32bit を割り切れる数）
pins = [Pin(2 + i, Pin.IN) for i in range(NCH)]
# CH0 GP2 = CLK_CPU  (U501-8)
# CH1 GP3 = ~WE_RAM  (U1101-21)
# CH2 GP4 = ~CS_RAM  (U1101-18)
# CH3 GP5 = MD5      (U1101-15)   06→B6 で 0→1 に変わるビット

WORDS = 8                    # RX FIFO を結合した深さ
SPW = 32 // NCH              # 1ワードあたりのサンプル数

@rp2.asm_pio(in_shiftdir=rp2.PIO.SHIFT_RIGHT, autopush=True, push_thresh=32,
             fifo_join=rp2.PIO.JOIN_RX)
def capture():
    wait(0, pin, 2)          # ~CS_RAM = L（EXE中）
    wait(0, pin, 0)          # CLK_CPU = L（EXE中間）
    wait(1, pin, 0)          # CLK_CPU ↑（EXE末）
    wrap_target()
    in_(pins, 4)             # ＝NCH（PIO内ではグローバル変数を使えない）。FIFOが満杯になると止まる＝最初の WORDS 語が連続サンプル
    wrap()

freq = machine.freq()        # 既定 125MHz → 8ns/サンプル
ns = 1_000_000_000 // freq
n = 0
uart.write("READY,{},{},{}\n".format(NCH, ns, WORDS * SPW))
while True:
    sm = rp2.StateMachine(0, capture, freq=freq, in_base=pins[0])
    sm.active(1)
    words = [sm.get() for _ in range(WORDS)]
    sm.active(0)
    while sm.rx_fifo():
        sm.get()
    n += 1
    uart.write("CAP,{},{},{},{}\n".format(n, NCH, ns, ",".join("{:08x}".format(w) for w in words)))

## Commit log (part)

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2026-05-27 TB-04 4bitアドレス版 KiCADプロジェクト 初回コミット
2026-05-27 KiCADファイルを4bit-addrディレクトリに移動
2026-05-27 カスタムシンボル・フットプリントを追加
2026-05-27 README: カスタムライブラリの登録手順を追記
2026-06-17 PCB最新編集をコミット（構成再編前）
    - ガーバー出力を.gitignoreに追加
2026-06-17 first push
2026-06-20 ローカル限定ファイル(CLAUDE.md・命令セット.xlsx)をgitignoreに追加
2026-06-27 ロジックアナライザーの回路図を追加。ロジアナのコードを少し変更
2026-06-27 チャンネル数の整合性を修正した
